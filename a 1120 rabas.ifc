Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView, QuantityTakeOffAddOnView]
File name: a 1120 rabas.ifc
Time: 2011-07-12T17:19:12
Author: PORTCM01/professeur
Organization: Structural Designer
Written by: IFC Database Version:Work
Made in: Tekla Structures 18.1 Build:12518/10.9.2012, IFC Export Version: 309Mar 29 2012

# IfcSite, Undefined
RefElevation: 0 mm

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: HEA100 (12)
In: Undefined
Description: HEA100; Material: /S275-E28
Tekla Common - Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: HEA100; Name: BAIONETTE; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Height: 96 mm; Width: 100 mm; sets with these values: 2
BaseQuantities - NetWeight: 0 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
BAIONETTE | 4114.39 | 4749.94 | 32282 | +3.534 | +4.695 | 100 | P8 | 0.00232245 | 0.00246645 | 0.002 | 0.679834 | 0.651448 | 1161.23
BAIONETTE | 4312.5 | -160.368 | 32282 | +3.930 | +4.695 | 96 | M4 | 0.00153 | 0.00162486 | 0.002 | 0.44923 | 0.429165 | 765
BAIONETTE | 4121.5 | -160.368 | 32202.1 | +4.074 | +4.170 | 95 | M4 | 0.000127665 | 0.00013558 | 0.00638325 | 0.0411505 | 0.03581 | 63.8325
BAIONETTE | 4414.36 | -7294.39 | 21258 | +4.132 | +4.695 | 99 | P11 | 0.00112254 | 0.00119613 | 0.002 | 0.33066 | 0.315926 | 563.148
BAIONETTE | 4388.95 | -8746.62 | 9258.87 | +4.081 | +4.695 | 102 | P6 | 0.0012242 | 0.00130366 | 0.002 | 0.360242 | 0.344329 | 613.778
BAIONETTE | 4388.95 | -8746.62 | 4973.87 | +4.081 | +4.695 | 102 | P5 | 0.0012242 | 0.00130366 | 0.002 | 0.360242 | 0.344329 | 613.778
BAIONETTE | 4388.95 | -8746.56 | 688.868 | +4.081 | +4.695 | 102 | P9 | 0.0012242 | 0.00130366 | 0.002 | 0.360242 | 0.344329 | 613.778
BAIONETTE | 4402.27 | -8024.89 | 15258 | +4.108 | +4.695 | 101 | P10 | 0.00117089 | 0.00124706 | 0.002 | 0.344732 | 0.329379 | 587.127
BAIONETTE | 4427.15 | -6563.84 | 27258 | +4.157 | +4.695 | 98 | P12 | 0.0010714 | 0.00114182 | 0.002 | 0.315778 | 0.301582 | 537.579
BAIONETTE | 4437.59 | -5967.16 | 32158 | +4.178 | +4.695 | 97 | P13 | 0.00102963 | 0.00109746 | 0.002 | 0.303624 | 0.289866 | 516.695
BAIONETTE | 4312.5 | -4190.36 | 32282 | +3.930 | +4.695 | 96 | M5 | 0.00153 | 0.00162486 | 0.002 | 0.44923 | 0.429165 | 765
BAIONETTE | 4121.5 | -4190.36 | 32202.1 | +4.074 | +4.170 | 95 | M5 | 0.000127665 | 0.00013558 | 0.00638325 | 0.0411505 | 0.03581 | 63.8325

# IfcBeam: HEA120 (16)
In: Undefined
Description: HEA120; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: -384.999 mm; Bottom elevation: -0.460; Top elevation: -0.310; Part mark: 75; Assembly mark: PS24B1; Phase: 1; Class: 2; Grade: S235JR; Profile: HEA120; Name: BECHE; sets with these values: 2
Tekla Quantity - Net weight: 2.83776 kg; Gross weight: 2.98377 kg; Weight: 2.98377 kg; Net volume: 0.000361498 m3; Gross volume: 0.000380098 m3; Gross footprint area: 0.00241 m2; Area per tons: 34.034 m2; Net surface area: 0.10952 m2; Gross area: 0.10155 m2; Height: 114 mm; Width: 120 mm; Length: 149.999 mm; sets with these values: 2
BaseQuantities - Length: 149.999 mm; OuterSurfaceArea: 0.10155 m2; NetVolume: 0.000361498 m3; NetWeight: 2.83776 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm)
BECHE | -175.365 | 32230
BECHE | -4175.31 | 32230
BECHE | 4685 | 688.868
BECHE | 4685 | 4973.87
BECHE | 4685 | 9258.87
BECHE | 4685 | 15258.9
BECHE | 4685 | 21258.9
BECHE | 4685 | 27258.9
BECHE | 4685 | 32158.9
BECHE | -8629.47 | 688.868
BECHE | -8629.47 | 4973.87
BECHE | -8629.47 | 9258.87
BECHE | -7868.04 | 15258.9
BECHE | -7137.49 | 21258.9
BECHE | -6406.93 | 27258.9
BECHE | -5810.31 | 32158.9

# IfcBeam: IPE120 (40)
In: Undefined
Description: IPE120; Material: /S275-E28
Tekla Common - Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: IPE120; Name: PANNE; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Height: 120 mm; Width: 64 mm; sets with these values: 2
BaseQuantities - NetWeight: 0 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark = Assembly mark | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
PANNE | 4380 | -1972.23 | 2831.37 | +4.320 | +4.440 | K5 | 0.005653 | 0.0058344 | 0.28288 | 2.15598 | 2.0995 | 4420
PANNE | 4380 | -1972.11 | 29708.9 | +4.320 | +4.440 | K4 | 0.00643956 | 0.0066462 | 0.32224 | 2.45561 | 2.39162 | 5035
PANNE | 4237.79 | -6036.52 | 29759.5 | +4.166 | +4.310 | K16 | 0.00643961 | 0.00664625 | 0 | 2.45563 | 2.39164 | 5035.04
PANNE | 4214.09 | -6713.69 | 24258.9 | +4.140 | +4.288 | K3 | 0.00772665 | 0.00797458 | 0 | 2.9459 | 2.86964 | 6041.35
PANNE | 4188.23 | -7452.33 | 18258.9 | +4.114 | +4.262 | K3 | 0.00772665 | 0.00797458 | 0 | 2.9459 | 2.86964 | 6041.35
PANNE | 4162.38 | -8190.98 | 12258.9 | +4.088 | +4.236 | K3 | 0.00772665 | 0.00797458 | 0 | 2.9459 | 2.86964 | 6041.35
PANNE | 4335.24 | -3252.12 | 4876.96 | +4.274 | +4.396 | K11 | 0.0112086 | 0.0115682 | 0 | 4.27229 | 4.16281 | 8763.81
PANNE | 4211.38 | -6790.91 | 4907.47 | +4.150 | +4.272 | K7 | 0.0111305 | 0.0114877 | 0 | 4.24256 | 4.13383 | 8702.79
PANNE | 4149.46 | -8560.3 | 4920.23 | +4.088 | +4.211 | K9 | 0.0110851 | 0.0114408 | 0 | 4.22526 | 4.11696 | 8667.28
PANNE | 4335.24 | -692.354 | 4853.9 | +4.274 | +4.396 | K10 | 0.0112624 | 0.0116238 | 0 | 4.29281 | 4.18282 | 8805.93
PANNE | 4211.38 | 2846.43 | 4823.32 | +4.150 | +4.272 | K6 | 0.0113407 | 0.0117046 | 0 | 4.32261 | 4.21187 | 8867.1
PANNE | 4149.46 | 4615.83 | 29744.9 | +4.088 | +4.211 | K15 | 0.00635387 | 0.00655776 | 0 | 2.42297 | 2.3598 | 4968
PANNE | 4149.46 | 4615.83 | 24258.9 | +4.088 | +4.211 | K1 | 0.00766864 | 0.00791472 | 0 | 2.92381 | 2.8481 | 5996
PANNE | 4149.46 | 4615.83 | 18258.9 | +4.088 | +4.211 | K1 | 0.00766864 | 0.00791472 | 0 | 2.92381 | 2.8481 | 5996
PANNE | 4149.46 | 4615.83 | 12258.9 | +4.088 | +4.211 | K1 | 0.00766864 | 0.00791472 | 0 | 2.92381 | 2.8481 | 5996
PANNE | 4149.46 | 4615.83 | 4808.02 | +4.088 | +4.211 | K2 | 0.0113798 | 0.011745 | 0 | 4.33751 | 4.2264 | 8897.69
PANNE | 4273.31 | -5021.51 | 4892.22 | +4.212 | +4.334 | K12 | 0.0111695 | 0.011528 | 0 | 4.25742 | 4.14832 | 8733.3
PANNE | 4273.31 | 1077.04 | 4838.61 | +4.212 | +4.334 | K13 | 0.0113016 | 0.0116642 | 0 | 4.30771 | 4.19735 | 8836.52
PANNE | 4211.38 | 2846.43 | 12258.9 | +4.150 | +4.272 | K21 | 0.00766864 | 0.00791472 | 0 | 2.92381 | 2.8481 | 5996
PANNE | 4211.38 | 2846.43 | 18258.9 | +4.150 | +4.272 | K21 | 0.00766864 | 0.00791472 | 0 | 2.92381 | 2.8481 | 5996
PANNE | 4211.38 | 2846.43 | 24258.9 | +4.150 | +4.272 | K21 | 0.00766864 | 0.00791472 | 0 | 2.92381 | 2.8481 | 5996
PANNE | 4211.38 | 2846.43 | 29744.9 | +4.150 | +4.272 | K8 | 0.00635387 | 0.00655776 | 0 | 2.42297 | 2.3598 | 4968
PANNE | 4273.31 | 1077.04 | 12258.9 | +4.212 | +4.334 | K17 | 0.00766864 | 0.00791472 | 0 | 2.92381 | 2.8481 | 5996
PANNE | 4273.31 | 1077.04 | 18258.9 | +4.212 | +4.334 | K17 | 0.00766864 | 0.00791472 | 0 | 2.92381 | 2.8481 | 5996
PANNE | 4273.31 | 1077.04 | 24258.9 | +4.212 | +4.334 | K17 | 0.00766864 | 0.00791472 | 0 | 2.92381 | 2.8481 | 5996
PANNE | 4273.31 | 1077.04 | 29744.9 | +4.212 | +4.334 | K19 | 0.00635387 | 0.00655776 | 0 | 2.42297 | 2.3598 | 4968
PANNE | 4335.24 | -692.354 | 12258.9 | +4.274 | +4.396 | K17 | 0.00766864 | 0.00791472 | 0 | 2.92381 | 2.8481 | 5996
PANNE | 4335.24 | -692.354 | 18258.9 | +4.274 | +4.396 | K17 | 0.00766864 | 0.00791472 | 0 | 2.92381 | 2.8481 | 5996
PANNE | 4335.24 | -692.354 | 24258.9 | +4.274 | +4.396 | K17 | 0.00766864 | 0.00791472 | 0 | 2.92381 | 2.8481 | 5996
PANNE | 4335.24 | -692.354 | 29744.9 | +4.274 | +4.396 | K20 | 0.00635387 | 0.00655776 | 0 | 2.42297 | 2.3598 | 4968
PANNE | 4211.38 | -6790.91 | 12258.9 | +4.150 | +4.272 | K21 | 0.00766864 | 0.00791472 | 0 | 2.92381 | 2.8481 | 5996
PANNE | 4211.38 | -6790.91 | 18509.9 | +4.150 | +4.272 | K14 | 0.00831068 | 0.00857736 | 0 | 3.16838 | 3.08655 | 6498
PANNE | 4273.31 | -5021.51 | 12258.9 | +4.212 | +4.334 | K17 | 0.00766864 | 0.00791472 | 0 | 2.92381 | 2.8481 | 5996
PANNE | 4273.31 | -5021.51 | 18258.9 | +4.212 | +4.334 | K17 | 0.00766864 | 0.00791472 | 0 | 2.92381 | 2.8481 | 5996
PANNE | 4273.31 | -5021.51 | 24258.9 | +4.212 | +4.334 | K17 | 0.00766864 | 0.00791472 | 0 | 2.92381 | 2.8481 | 5996
PANNE | 4273.31 | -5021.51 | 29744.9 | +4.212 | +4.334 | K19 | 0.00635387 | 0.00655776 | 0 | 2.42297 | 2.3598 | 4968
PANNE | 4335.24 | -3252.12 | 12258.9 | +4.274 | +4.396 | K17 | 0.00766864 | 0.00791472 | 0 | 2.92381 | 2.8481 | 5996
PANNE | 4335.24 | -3252.12 | 18258.9 | +4.274 | +4.396 | K18 | 0.00766864 | 0.00791472 | 0 | 2.92381 | 2.8481 | 5996
PANNE | 4335.24 | -3252.12 | 24258.9 | +4.274 | +4.396 | K18 | 0.00766864 | 0.00791472 | 0 | 2.92381 | 2.8481 | 5996
PANNE | 4335.24 | -3252.12 | 29744.9 | +4.274 | +4.396 | K22 | 0.00635387 | 0.00655776 | 0 | 2.42297 | 2.3598 | 4968

# IfcBeam: IPE270 (14)
In: Undefined
Description: IPE270; Material: /S275-E28
Tekla Common - Top elevation: +4.319; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: IPE270; Name: TRAVERSE; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Gross footprint area: 0 m2; Height: 270 mm; Width: 135 mm; sets with these values: 2
BaseQuantities - NetWeight: 0 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Part mark | Assembly mark | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
TRAVERSE | 4120.59 | -3810.39 | 32158.9 | +3.922 | 35 | T9 | 0.0160575 | 0.0167894 | 3.90081 | 3.80778 | 3657.81
TRAVERSE | 4071.25 | 1275.29 | 32158.9 | +3.823 | 33 | T7 | 0.0284735 | 0.0297369 | 6.91021 | 6.74426 | 6478.64
TRAVERSE | 4110.14 | -4108.7 | 27258.9 | +3.901 | 32 | T6 | 0.018685 | 0.0195295 | 4.53768 | 4.42925 | 4254.8
TRAVERSE | 4071.25 | 1275.29 | 27258.9 | +3.823 | 36 | T10 | 0.0284735 | 0.0297369 | 6.91021 | 6.74426 | 6478.64
TRAVERSE | 4097.36 | -4473.98 | 21258.9 | +3.875 | 31 | T5 | 0.0219024 | 0.0228849 | 5.31751 | 5.19023 | 4985.81
TRAVERSE | 4071.25 | 1275.29 | 21258.9 | +3.823 | 29 | T3 | 0.0284735 | 0.0297369 | 6.91021 | 6.74426 | 6478.64
TRAVERSE | 4071.25 | 1275.29 | 9258.87 | +3.823 | 28 | T2 | 0.0284735 | 0.0297369 | 6.91021 | 6.74426 | 6478.64
TRAVERSE | 4071.25 | -5219.94 | 9258.87 | +3.823 | 34 | T8 | 0.028473 | 0.029737 | 6.91007 | 6.74427 | 6478.64
TRAVERSE | 4071.25 | -5219.94 | 4973.87 | +3.823 | 27 | T1 | 0.028473 | 0.029737 | 6.91007 | 6.74427 | 6478.64
TRAVERSE | 4071.25 | 1275.29 | 4973.87 | +3.823 | 27 | T1 | 0.0284735 | 0.0297369 | 6.91021 | 6.74426 | 6478.64
TRAVERSE | 4084.58 | -4839.26 | 15258.9 | +3.850 | 30 | T4 | 0.0251199 | 0.0262402 | 6.09735 | 5.9512 | 5716.81
TRAVERSE | 4071.25 | 1275.29 | 15258.9 | +3.823 | 29 | T3 | 0.0284735 | 0.0297369 | 6.91021 | 6.74426 | 6478.64
TRAVERSE | 4071.25 | 1275.29 | 688.868 | +3.823 | 36 | T10 | 0.0284735 | 0.0297369 | 6.91021 | 6.74426 | 6478.64
TRAVERSE | 4071.25 | -5219.91 | 688.868 | +3.823 | 36 | T10 | 0.0284727 | 0.0297367 | 6.91001 | 6.74421 | 6478.59

# IfcBeam: IPE330 (14)
In: Undefined
Description: IPE330; Material: /S275-E28
Tekla Common - Bottom elevation: -0.285; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: IPE330; Name: POTEAU; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Gross footprint area: 0 m2; Height: 330 mm; Width: 160 mm; sets with these values: 2
BaseQuantities - NetWeight: 0 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Top elevation | Part mark | Assembly mark | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
POTEAU | 1946.33 | -5810.22 | 32158.9 | +4.183 | 26 | P13 | 0.0266979 | 0.0279724 | 5.74649 | 5.60342 | 4468.44
POTEAU | 1935.89 | -6406.84 | 27258.9 | +4.163 | 25 | P12 | 0.026573 | 0.0278417 | 5.71966 | 5.57724 | 4447.56
POTEAU | 1897 | 4684.79 | 32158.9 | +4.085 | 22 | P8 | 0.0261076 | 0.0273547 | 5.6197 | 5.47969 | 4369.77
POTEAU | 1897 | 4684.79 | 27258.9 | +4.085 | 22 | P7 | 0.0261076 | 0.0273547 | 5.6197 | 5.47969 | 4369.77
POTEAU | 1897 | 4684.79 | 21258.9 | +4.085 | 22 | P7 | 0.0261076 | 0.0273547 | 5.6197 | 5.47969 | 4369.77
POTEAU | 1897 | -8629.38 | 9258.87 | +4.085 | 21 | P6 | 0.0261076 | 0.0273547 | 5.6197 | 5.47969 | 4369.77
POTEAU | 1897 | 4684.79 | 9258.87 | +4.085 | 21 | P4 | 0.0261076 | 0.0273547 | 5.6197 | 5.47969 | 4369.77
POTEAU | 1897 | -8629.32 | 688.868 | +4.085 | 22 | P9 | 0.0261076 | 0.0273547 | 5.6197 | 5.47969 | 4369.77
POTEAU | 1897 | 4684.85 | 688.868 | +4.085 | 22 | P7 | 0.0261076 | 0.0273547 | 5.6197 | 5.47969 | 4369.77
POTEAU | 1897 | 4684.79 | 15258.9 | +4.085 | 22 | P7 | 0.0261076 | 0.0273547 | 5.6197 | 5.47969 | 4369.77
POTEAU | 1897 | -8629.38 | 4973.87 | +4.085 | 21 | P5 | 0.0261076 | 0.0273547 | 5.6197 | 5.47969 | 4369.77
POTEAU | 1897 | 4684.79 | 4973.87 | +4.085 | 21 | P3 | 0.0261076 | 0.0273547 | 5.6197 | 5.47969 | 4369.77
POTEAU | 1923.11 | -7137.4 | 21258.9 | +4.137 | 24 | P11 | 0.02642 | 0.0276816 | 5.6868 | 5.54517 | 4421.99
POTEAU | 1910.32 | -7867.96 | 15258.9 | +4.111 | 23 | P10 | 0.026267 | 0.0275216 | 5.65394 | 5.51311 | 4396.42

# IfcBeam: IPN160 (10)
In: Undefined
Description: IPN160; Material: /S275-E28
Tekla Common - Bottom elevation: +0.000; Phase: 1; Class: 13; Grade: S275-E28; Profile: IPN160; Name: POTEAU; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Gross footprint area: 0.00226444 m2; Height: 160 mm; Width: 74 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
BaseQuantities - NetWeight: 0 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Top elevation | Part mark = Assembly mark | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
POTEAU | 2000 | 4920 | 31237.5 | +4.000 | P2 | 0.00905778 | 0.00912 | 2.34759 | 2.3 | 4000
POTEAU | 2000 | 4920 | 27807.5 | +4.000 | P2 | 0.00905778 | 0.00912 | 2.34759 | 2.3 | 4000
POTEAU | 2000 | 4920 | 24337.5 | +4.000 | P2 | 0.00905778 | 0.00912 | 2.34759 | 2.3 | 4000
POTEAU | 2400 | 5081.22 | 32416.4 | +4.800 | P1 | 0.0108693 | 0.010944 | 2.8162 | 2.76 | 4800
POTEAU | 2400 | 5080 | 27282.5 | +4.800 | P1 | 0.0108693 | 0.010944 | 2.8162 | 2.76 | 4800
POTEAU | 2400 | 5080 | 24292.5 | +4.800 | P1 | 0.0108693 | 0.010944 | 2.8162 | 2.76 | 4800
POTEAU | 2000 | 4920 | 20997.5 | +4.000 | P2 | 0.00905778 | 0.00912 | 2.34759 | 2.3 | 4000
POTEAU | 2400 | 5080 | 19212.5 | +4.800 | P1 | 0.0108693 | 0.010944 | 2.8162 | 2.76 | 4800
POTEAU | 2400 | 5080 | 14722.5 | +4.800 | P1 | 0.0108693 | 0.010944 | 2.8162 | 2.76 | 4800
POTEAU | 2400 | 5080 | 10202.5 | +4.800 | P1 | 0.0108693 | 0.010944 | 2.8162 | 2.76 | 4800

# IfcBeam: L40*4 (56)
In: Undefined
Description: L40*4; Material: /S275-E28
Tekla Common - Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: L40*4; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Height: 40 mm; Width: 40 mm; sets with these values: 2
BaseQuantities - NetWeight: 0 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark = Assembly mark | Name | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
CV | 4216.47 | 657.889 | 6076.97 | +4.145 | +4.272 | CV1 | CV | 0.00097043 | 0.000983199 | 0 | 0.511361 | 0.494792 | 3192.2
STABILITE | 1823.42 | -8709.07 | 7110.37 | -0.230 | +3.865 | ST1 | STABILITE | 0.00175847 | 0.00178161 | 0 | 0.926119 | 0.896588 | 5784.44
STABILITE | 1823.43 | -8680.12 | 7122.36 | -0.230 | +3.865 | ST1 | STABILITE | 0.00175848 | 0.00178161 | 0 | 0.926121 | 0.896591 | 5784.46
STABILITE | 1823.43 | 4735.53 | 7122.36 | -0.230 | +3.865 | ST1 | STABILITE | 0.00175848 | 0.00178161 | 0 | 0.926121 | 0.896591 | 5784.46
STABILITE | 1823.42 | 4764.47 | 7110.37 | -0.230 | +3.865 | ST1 | STABILITE | 0.00175847 | 0.00178161 | 0 | 0.926119 | 0.896588 | 5784.44
CV | 4125.76 | -7194.04 | 8169.41 | +4.054 | +4.181 | CV1 | CV | 0.000970447 | 0.000983216 | 0 | 0.511369 | 0.4948 | 3192.26
CV | 4263.89 | -2593.39 | 8140.12 | +4.235 | +4.275 | CV2 | CV | 0.000697498 | 0.000706676 | 0.0917761 | 0.367712 | 0.355632 | 2294.4
CV | 4216.09 | -4613.03 | 8169.22 | +4.144 | +4.272 | CV1 | CV | 0.000970353 | 0.000983121 | 0 | 0.51132 | 0.494753 | 3191.95
LIEN | 4170.92 | -5903.7 | 12220.3 | +4.110 | +4.214 | L12 | LIEN | 0.000557681 | 0.000565019 | 0 | 0.294124 | 0.284344 | 1834.48
LIEN | 4232.85 | -4134.3 | 12280.3 | +4.172 | +4.276 | L12 | LIEN | 0.00055768 | 0.000565018 | 0 | 0.294124 | 0.284344 | 1834.48
LIEN | 4263.8 | -1971.82 | 12237.4 | +4.235 | +4.275 | L15 | LIEN | 0.000798888 | 0.0008094 | 0.105117 | 0.421075 | 0.407328 | 2627.92
LIEN | 4263.8 | -1972.92 | 7124.89 | +4.235 | +4.275 | L11 | LIEN | 0.000798888 | 0.0008094 | 0.105117 | 0.421075 | 0.407328 | 2627.92
LIEN | 4232.85 | -4134.3 | 18280.3 | +4.172 | +4.276 | L12 | LIEN | 0.00055768 | 0.000565018 | 0 | 0.294124 | 0.284344 | 1834.48
CV | 4125.38 | 3260.44 | 6076.95 | +4.053 | +4.181 | CV1 | CV | 0.000970507 | 0.000983276 | 0 | 0.511401 | 0.494831 | 3192.46
CV | 4216.09 | 668.571 | 8169.22 | +4.144 | +4.272 | CV1 | CV | 0.000970353 | 0.000983121 | 0 | 0.51132 | 0.494752 | 3191.95
CV | 4125.76 | 3249.58 | 8169.41 | +4.054 | +4.181 | CV1 | CV | 0.000970446 | 0.000983215 | 0 | 0.511369 | 0.4948 | 3192.26
CV | 4296.93 | -1351.9 | 8140.24 | +4.285 | +4.325 | CV2 | CV | 0.000697578 | 0.000706756 | 0.00917865 | 0.367754 | 0.355673 | 2294.66
CV | 4296.83 | -2578.74 | 6083.87 | +4.285 | +4.325 | CV2 | CV | 0.000697497 | 0.000706675 | 0.0091776 | 0.367712 | 0.355632 | 2294.4
LIEN | 4170.92 | 1959.24 | 12220.3 | +4.110 | +4.214 | L12 | LIEN | 0.000557681 | 0.000565019 | 0 | 0.294125 | 0.284344 | 1834.48
LIEN | 4232.85 | 189.842 | 12280.3 | +4.172 | +4.276 | L12 | LIEN | 0.000557681 | 0.000565018 | 0 | 0.294124 | 0.284344 | 1834.48
LIEN | 4108.99 | 3728.63 | 12280.3 | +4.048 | +4.153 | L10 | LIEN | 0.000557682 | 0.00056502 | 0 | 0.294125 | 0.284344 | 1834.48
LIEN | 4232.85 | 189.842 | 18280.3 | +4.172 | +4.276 | L12 | LIEN | 0.00055768 | 0.000565018 | 0 | 0.294124 | 0.284344 | 1834.48
LIEN | 4170.92 | 1959.24 | 18220.3 | +4.110 | +4.214 | L12 | LIEN | 0.000557681 | 0.000565019 | 0 | 0.294124 | 0.284344 | 1834.48
LIEN | 4108.99 | 3728.63 | 18280.3 | +4.048 | +4.153 | L10 | LIEN | 0.000557682 | 0.00056502 | 0 | 0.294125 | 0.284344 | 1834.48
LIEN | 4232.85 | 189.842 | 24280.3 | +4.172 | +4.276 | L12 | LIEN | 0.00055768 | 0.000565018 | 0 | 0.294124 | 0.284344 | 1834.48
LIEN | 4170.92 | 1959.24 | 24220.3 | +4.110 | +4.214 | L12 | LIEN | 0.000557681 | 0.000565019 | 0 | 0.294124 | 0.284344 | 1834.48
LIEN | 4108.99 | 3728.63 | 24280.3 | +4.048 | +4.153 | L10 | LIEN | 0.000557682 | 0.00056502 | 0 | 0.294125 | 0.284344 | 1834.48
LIEN | 4232.85 | 189.842 | 29700.3 | +4.172 | +4.276 | L12 | LIEN | 0.00055768 | 0.000565018 | 0 | 0.294124 | 0.284344 | 1834.48
LIEN | 4170.92 | 1959.24 | 29640.3 | +4.110 | +4.214 | L12 | LIEN | 0.000557681 | 0.000565019 | 0 | 0.294124 | 0.284344 | 1834.48
LIEN | 4108.99 | 3728.63 | 29700.3 | +4.048 | +4.153 | L12 | LIEN | 0.000557682 | 0.00056502 | 0 | 0.294125 | 0.284344 | 1834.48
LIEN | 4232.85 | 189.842 | 2852.84 | +4.172 | +4.276 | L12 | LIEN | 0.00055768 | 0.000565018 | 0 | 0.294124 | 0.284344 | 1834.48
LIEN | 4170.92 | 1959.24 | 2792.84 | +4.110 | +4.214 | L12 | LIEN | 0.000557681 | 0.000565019 | 0 | 0.294124 | 0.284344 | 1834.48
LIEN | 4108.99 | 3728.63 | 2852.84 | +4.048 | +4.153 | L12 | LIEN | 0.000557682 | 0.00056502 | 0 | 0.294125 | 0.284344 | 1834.48
LIEN | 4232.85 | 189.842 | 7168 | +4.172 | +4.276 | L12 | LIEN | 0.00055768 | 0.000565018 | 0 | 0.294124 | 0.284344 | 1834.47
LIEN | 4170.92 | 1959.24 | 7108 | +4.110 | +4.214 | L7 | LIEN | 0.000557681 | 0.000565019 | 0 | 0.294124 | 0.284344 | 1834.48
LIEN | 4108.99 | 3728.63 | 7168 | +4.048 | +4.153 | L12 | LIEN | 0.000557682 | 0.00056502 | 0 | 0.294125 | 0.284344 | 1834.48
LIEN | 4170.92 | -5903.7 | 18220.3 | +4.110 | +4.214 | L12 | LIEN | 0.000557681 | 0.000565019 | 0 | 0.294124 | 0.284344 | 1834.48
LIEN | 4232.85 | -4134.3 | 24280.3 | +4.172 | +4.276 | L12 | LIEN | 0.00055768 | 0.000565018 | 0 | 0.294124 | 0.284344 | 1834.48
LIEN | 4232.85 | -4134.3 | 29700.3 | +4.172 | +4.276 | L12 | LIEN | 0.00055768 | 0.000565018 | 0 | 0.294124 | 0.284344 | 1834.48
LIEN | 4263.8 | -1972.24 | 2809.89 | +4.235 | +4.275 | L15 | LIEN | 0.000798888 | 0.0008094 | 0.105117 | 0.421075 | 0.407328 | 2627.92
LIEN | 4232.85 | -4134.3 | 2852.84 | +4.172 | +4.276 | L12 | LIEN | 0.00055768 | 0.000565018 | 0 | 0.294124 | 0.284344 | 1834.48
LIEN | 4170.92 | -5903.7 | 2792.84 | +4.110 | +4.214 | L12 | LIEN | 0.000557681 | 0.000565019 | 0 | 0.294124 | 0.284344 | 1834.48
LIEN | 4108.99 | -7673.09 | 2852.84 | +4.048 | +4.153 | L12 | LIEN | 0.000557682 | 0.00056502 | 0 | 0.294125 | 0.284344 | 1834.48
LIEN | 4232.85 | -4134.3 | 7168 | +4.172 | +4.276 | L12 | LIEN | 0.00055768 | 0.000565018 | 0 | 0.294124 | 0.284344 | 1834.48
LIEN | 4170.92 | -5903.7 | 7108 | +4.110 | +4.214 | L7 | LIEN | 0.000557681 | 0.000565019 | 0 | 0.294124 | 0.284344 | 1834.48
LIEN | 4108.99 | -7673.09 | 7168 | +4.048 | +4.153 | L12 | LIEN | 0.000557682 | 0.00056502 | 0 | 0.294125 | 0.284344 | 1834.48
LIEN | 4263.8 | -1972.48 | 24237.4 | +4.235 | +4.275 | L16 | LIEN | 0.000798888 | 0.0008094 | 0.105117 | 0.421075 | 0.407328 | 2627.92
LIEN | 4263.8 | -1971.82 | 18237.4 | +4.235 | +4.275 | L15 | LIEN | 0.000798888 | 0.0008094 | 0.105117 | 0.421075 | 0.407328 | 2627.92
CV | 4125.38 | -7204.9 | 6076.95 | +4.053 | +4.181 | CV1 | CV | 0.000970506 | 0.000983276 | 0 | 0.511401 | 0.494831 | 3192.46
CV | 4216.47 | -4602.33 | 6076.95 | +4.145 | +4.272 | CV1 | CV | 0.000970414 | 0.000983182 | 0 | 0.511352 | 0.494783 | 3192.15
LIEN | 4115.47 | -7487.94 | 12280.3 | +4.061 | +4.153 | L8 | LIEN | 0.000445042 | 0.000450898 | 0 | 0.23484 | 0.226913 | 1463.95
LIEN | 4183.84 | -5534.67 | 29640.3 | +4.136 | +4.214 | L13 | LIEN | 0.000333176 | 0.00033756 | 0 | 0.175964 | 0.169876 | 1095.97
LIEN | 4128.4 | -7118.62 | 18280.3 | +4.087 | +4.153 | L9 | LIEN | 0.000220356 | 0.000223255 | 0 | 0.116585 | 0.112353 | 724.855
LIEN | 4172.16 | -5868.29 | 24220.3 | +4.113 | +4.214 | L14 | LIEN | 0.000536142 | 0.000543197 | 0 | 0.282788 | 0.273362 | 1763.63
LIEN | 4263.8 | -1972.36 | 29657.4 | +4.235 | +4.275 | L16 | LIEN | 0.000798888 | 0.0008094 | 0.105117 | 0.421075 | 0.407328 | 2627.92
CV | 4263.98 | -1366.49 | 6083.67 | +4.235 | +4.275 | CV2 | CV | 0.000697638 | 0.000706817 | 0.0917944 | 0.367786 | 0.355703 | 2294.86

# IfcBeam: L50*5, ATTACHE
In: Undefined
Description: L50*5; Material: /S275-E28
Tekla Common - Center of gravity Z: 2085.66 mm; Center of gravity Y: -5631.02 mm; Center of gravity X: 32209.4 mm; Bottom elevation: +2.050; Top elevation: +2.100; Part mark: A1; Assembly mark: A1; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: L50*5; Name: ATTACHE; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.000114538 m3; Gross volume: 0.000115744 m3; Gross footprint area: 0.0120566 m2; Net surface area: 0.0491765 m2; Gross area: 0.0467797 m2; Height: 50 mm; Width: 50 mm; Length: 241.132 mm; sets with these values: 2
BaseQuantities - Length: 241.132 mm; OuterSurfaceArea: 0.0467797 m2; NetVolume: 0.000114538 m3; NetWeight: 0 kg

# IfcBeam: L60*6 (4)
In: Undefined
Description: L60*6; Material: /S275-E28
Tekla Common - Center of gravity Y: 5017.21 mm; Phase: 2; Class: 5; Grade: S275-E28; Profile: L60*6; Name: LISSE; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Height: 60 mm; Width: 60 mm; sets with these values: 2
BaseQuantities - NetWeight: 0 kg
Name | Center of gravity Z (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark = Assembly mark | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
LISSE | 4251.92 | 7186.37 | +3.804 | +4.700 | L20 | 0.000612973 | 0.000619246 | 0.000684 | 0.216446 | 0.208805 | 896.16
LISSE | 4251.92 | 7151.95 | +3.804 | +4.700 | L20 | 0.000612973 | 0.000619246 | 0.000684 | 0.216446 | 0.208805 | 896.16
LISSE | 3885 | 10122.8 | +2.970 | +4.800 | L19 | 0.00125172 | 0.00126453 | 0.000684 | 0.440568 | 0.42639 | 1830
LISSE | 3901.57 | 6884.65 | +2.970 | +4.858 | L18 | 0.00463201 | 0.00467942 | 0 | 1.62664 | 1.57786 | 6771.95

# IfcBeam: PL10*135 (14)
In: Undefined
Description: PL10*135; Material: /S275-E28
Tekla Common - Part mark: 69; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL10*135; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.00205258 m3; Gross volume: 0.00205258 m3; Gross footprint area: 0 m2; Net surface area: 0.443624 m2; Gross area: 0.443624 m2; Height: 135 mm; Width: 10 mm; Length: 1520.43 mm; sets with these values: 2
BaseQuantities - Length: 1520.43 mm; OuterSurfaceArea: 0.443624 m2; NetVolume: 0.00205258 m3; NetWeight: 0 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Assembly mark
GOUSSET | 3714.05 | 3762.98 | 4973.87 | +3.553 | +3.875 | T1
GOUSSET | 3714.05 | -7707.57 | 4973.87 | +3.553 | +3.875 | T1
GOUSSET | 3714.05 | -7707.57 | 688.868 | +3.553 | +3.875 | T10
GOUSSET | 3714.05 | 3762.98 | 688.868 | +3.553 | +3.875 | T10
GOUSSET | 3714.05 | 3762.98 | 9258.87 | +3.553 | +3.875 | T2
GOUSSET | 3714.05 | 3762.98 | 15258.9 | +3.553 | +3.875 | T3
GOUSSET | 3714.05 | 3762.98 | 27258.9 | +3.553 | +3.875 | T10
GOUSSET | 3714.05 | 3762.98 | 21258.9 | +3.553 | +3.875 | T3
GOUSSET | 3714.05 | -7707.57 | 9258.87 | +3.553 | +3.875 | T8
GOUSSET | 3740.69 | -6946.2 | 15258.9 | +3.580 | +3.902 | T4
GOUSSET | 3766.26 | -6215.64 | 21258.9 | +3.605 | +3.927 | T5
GOUSSET | 3791.83 | -5485.09 | 27258.9 | +3.631 | +3.953 | T6
GOUSSET | 3812.71 | -4888.46 | 32158.9 | +3.652 | +3.974 | T9
GOUSSET | 3714.05 | 3762.98 | 32158.9 | +3.553 | +3.875 | T7

# IfcBeam: PL10*350 (16)
In: Undefined
Description: PL10*350; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: -305 mm; Bottom elevation: -0.310; Top elevation: -0.300; Part mark: 68; Assembly mark: PS24B1; Phase: 1; Class: 2; Finish: BRUT; Grade: S235JR; Profile: PL10*350; Name: PRESCELLE; sets with these values: 2
Tekla Quantity - Area per tons: 27.9042 m2; Net surface area: 0.115 m2; Gross area: 0.115 m2; Height: 350 mm; Width: 10 mm; Length: 150 mm; sets with these values: 2
BaseQuantities - Length: 150 mm; OuterSurfaceArea: 0.115 m2
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Net weight (kg) = Gross weight (kg) = Weight (kg) = NetWeight (kg) | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2)
PRESCELLE | -175.365 | 32230 | 4.12124 | 0.000524999 | 0.0524999
PRESCELLE | -4175.31 | 32230 | 4.12124 | 0.000524999 | 0.0524999
PRESCELLE | -8629.47 | 688.868 | 4.12125 | 0.000524999 | 0.0524999
PRESCELLE | 4685 | 4973.87 | 4.12125 | 0.000525 | 0.0525
PRESCELLE | 4685 | 688.868 | 4.12125 | 0.000525 | 0.0525
PRESCELLE | 4685 | 9258.87 | 4.12125 | 0.000525 | 0.0525
PRESCELLE | 4685 | 15258.9 | 4.12125 | 0.000525 | 0.0525
PRESCELLE | 4685 | 21258.9 | 4.12125 | 0.000525 | 0.0525
PRESCELLE | 4685 | 27258.9 | 4.12125 | 0.000525 | 0.0525
PRESCELLE | 4685 | 32158.9 | 4.12125 | 0.000524999 | 0.0524999
PRESCELLE | -8629.47 | 4973.87 | 4.12125 | 0.000525 | 0.0525
PRESCELLE | -8629.47 | 9258.87 | 4.12125 | 0.000525 | 0.0525
PRESCELLE | -7868.04 | 15258.9 | 4.12125 | 0.000524999 | 0.0524999
PRESCELLE | -7137.49 | 21258.9 | 4.12125 | 0.000524999 | 0.0524999
PRESCELLE | -6406.93 | 27258.9 | 4.12125 | 0.000524999 | 0.0524999
PRESCELLE | -5810.31 | 32158.9 | 4.12125 | 0.000524999 | 0.0524999

# IfcBeam: PL100*4300, GOUSSET
In: Undefined
Description: PL100*4300; Material: /S235-E24
Tekla Common - Center of gravity Z: 1962.44 mm; Center of gravity Y: 2330.87 mm; Center of gravity X: 20800 mm; Bottom elevation: -0.000; Top elevation: +4.300; Part mark: G2; Assembly mark: G2; Phase: 1; Class: 0; Grade: S235-E24; Profile: PL100*4300; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 2.15975 m3; Gross volume: 2.15975 m3; Gross footprint area: 0 m2; Net surface area: 45.0869 m2; Gross area: 23.7392 m2; Height: 4300 mm; Width: 100 mm; Length: 5520.74 mm; sets with these values: 2
BaseQuantities - Length: 5520.74 mm; OuterSurfaceArea: 45.0869 m2; NetVolume: 2.15975 m3; NetWeight: 0 kg

# IfcBeam: PL12*135 (14)
In: Undefined
Description: PL12*135; Material: /S275-E28
Tekla Common - Part mark: 81; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL12*135; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.000891 m3; Gross volume: 0.000891 m3; Gross footprint area: 0.00162 m2; Net surface area: 0.16494 m2; Gross area: 0.16494 m2; Height: 135 mm; Width: 12 mm; Length: 550 mm; sets with these values: 2
BaseQuantities - Length: 550 mm; OuterSurfaceArea: 0.16494 m2; NetVolume: 0.000891 m3; NetWeight: 0 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Assembly mark
GOUSSET | 3813.19 | -8458.52 | 4973.87 | +3.538 | +4.088 | T1
GOUSSET | 3813.19 | -8458.52 | 688.868 | +3.538 | +4.088 | T10
GOUSSET | 3813.19 | 4513.94 | 688.868 | +3.538 | +4.088 | T10
GOUSSET | 3813.19 | 4513.94 | 4973.87 | +3.538 | +4.088 | T1
GOUSSET | 3813.19 | 4513.94 | 9258.87 | +3.538 | +4.088 | T2
GOUSSET | 3813.19 | 4513.94 | 15258.9 | +3.538 | +4.088 | T3
GOUSSET | 3813.19 | 4513.94 | 27258.9 | +3.538 | +4.088 | T10
GOUSSET | 3813.19 | 4513.94 | 21258.9 | +3.538 | +4.088 | T3
GOUSSET | 3813.19 | -8458.52 | 9258.87 | +3.538 | +4.088 | T8
GOUSSET | 3839.84 | -7697.16 | 15258.9 | +3.565 | +4.115 | T4
GOUSSET | 3865.41 | -6966.6 | 21258.9 | +3.590 | +4.140 | T5
GOUSSET | 3890.98 | -6236.04 | 27258.9 | +3.616 | +4.166 | T6
GOUSSET | 3911.86 | -5639.42 | 32158.9 | +3.637 | +4.187 | T9
GOUSSET | 3813.19 | 4513.94 | 32158.9 | +3.538 | +4.088 | T7

# IfcBeam: PL15*135 (7)
In: Undefined
Description: PL15*135; Material: /S275-E28
Tekla Common - Center of gravity Z: 4184.39 mm; Center of gravity Y: -1964.86 mm; Bottom elevation: +4.054; Top elevation: +4.314; Part mark: 70; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL15*135; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.000526875 m3; Gross volume: 0.000526875 m3; Gross footprint area: 0.002025 m2; Net surface area: 0.0821056 m2; Gross area: 0.0821056 m2; Height: 135 mm; Width: 15 mm; Length: 260.185 mm; sets with these values: 2
BaseQuantities - Length: 260.185 mm; OuterSurfaceArea: 0.0821056 m2; NetVolume: 0.000526875 m3; NetWeight: 0 kg
Name | Center of gravity X (mm) | Assembly mark
GOUSSET | 4973.87 | T1
GOUSSET | 688.868 | T10
GOUSSET | 9258.87 | T2
GOUSSET | 15258.9 | T3
GOUSSET | 21258.9 | T3
GOUSSET | 27258.9 | T10
GOUSSET | 32158.9 | T7

# IfcBeam: PL15*210 (2)
In: Undefined
Description: PL15*210; Material: /S275-E28
Tekla Common - Center of gravity Z: -292.5 mm; Center of gravity X: 32230 mm; Bottom elevation: -0.300; Top elevation: -0.285; Part mark: 73; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL15*210; Name: PLATINE; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.0009135 m3; Gross volume: 0.0009135 m3; Gross footprint area: 0.0609 m2; Net surface area: 0.1368 m2; Gross area: 0.1368 m2; Height: 210 mm; Width: 15 mm; Length: 290 mm; sets with these values: 2
BaseQuantities - Length: 290 mm; OuterSurfaceArea: 0.1368 m2; NetVolume: 0.0009135 m3; NetWeight: 0 kg
Name | Center of gravity Y (mm) | Assembly mark
PLATINE | -175.365 | M4
PLATINE | -4175.31 | M5

# IfcBeam: PL15*315 (14)
In: Undefined
Description: PL15*315; Material: /S275-E28
Tekla Common - Center of gravity Z: -292.5 mm; Bottom elevation: -0.300; Top elevation: -0.285; Part mark: 72; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL15*315; Name: PLATINE; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.00137025 m3; Gross volume: 0.00137025 m3; Gross footprint area: 0.09135 m2; Net surface area: 0.20085 m2; Gross area: 0.20085 m2; Height: 315 mm; Width: 15 mm; Length: 290 mm; sets with these values: 2
BaseQuantities - Length: 290 mm; OuterSurfaceArea: 0.20085 m2; NetVolume: 0.00137025 m3; NetWeight: 0 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Assembly mark
PLATINE | -8629.47 | 688.868 | P9
PLATINE | 4685 | 4973.87 | P3
PLATINE | 4685 | 688.868 | P7
PLATINE | 4685 | 9258.87 | P4
PLATINE | 4685 | 15258.9 | P7
PLATINE | 4685 | 21258.9 | P7
PLATINE | 4685 | 27258.9 | P7
PLATINE | 4685 | 32158.9 | P8
PLATINE | -8629.47 | 4973.87 | P5
PLATINE | -8629.47 | 9258.87 | P6
PLATINE | -7868.04 | 15258.9 | P10
PLATINE | -7137.49 | 21258.9 | P11
PLATINE | -6406.93 | 27258.9 | P12
PLATINE | -5810.31 | 32158.9 | P13

# IfcBeam: PL15*90 (64)
In: Undefined
Description: PL15*90; Material: STEEL/S235JR
Tekla Common - Part mark: 71; Assembly mark: PS24B1; Phase: 1; Class: 2; Finish: BRUT; Grade: S235JR; Profile: PL15*90; Name: GOUSSET SOUDE; sets with these values: 2
Tekla Quantity - Net weight: 0.953775 kg; Gross weight: 0.953775 kg; Weight: 0.953775 kg; Net volume: 0.0001215 m3; Gross volume: 0.0001215 m3; Gross footprint area: 0.0081 m2; Area per tons: 22.6469 m2; Net surface area: 0.0216 m2; Gross area: 0.0216 m2; Height: 90 mm; Width: 15 mm; Length: 90 mm; sets with these values: 2
BaseQuantities - Length: 90 mm; OuterSurfaceArea: 0.0216 m2; NetVolume: 0.0001215 m3; NetWeight: 0.953775 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation
GOUSSET SOUDE | -672.5 | -100.364 | 32230 | -0.680 | -0.665
GOUSSET SOUDE | -672.5 | -250.364 | 32230 | -0.680 | -0.665
GOUSSET SOUDE | -267.5 | -100.364 | 32230 | -0.275 | -0.260
GOUSSET SOUDE | -267.5 | -250.364 | 32230 | -0.275 | -0.260
GOUSSET SOUDE | -672.5 | -4100.31 | 32230 | -0.680 | -0.665
GOUSSET SOUDE | -672.5 | -4250.31 | 32230 | -0.680 | -0.665
GOUSSET SOUDE | -267.5 | -4100.31 | 32230 | -0.275 | -0.260
GOUSSET SOUDE | -267.5 | -4250.31 | 32230 | -0.275 | -0.260
GOUSSET SOUDE | -267.5 | -8629.47 | 613.869 | -0.275 | -0.260
GOUSSET SOUDE | -267.5 | 4685 | 4898.87 | -0.275 | -0.260
GOUSSET SOUDE | -267.5 | 4685 | 613.869 | -0.275 | -0.260
GOUSSET SOUDE | -267.5 | 4685 | 763.869 | -0.275 | -0.260
GOUSSET SOUDE | -672.5 | 4685 | 613.869 | -0.680 | -0.665
GOUSSET SOUDE | -672.5 | 4685 | 763.869 | -0.680 | -0.665
GOUSSET SOUDE | -267.5 | 4685 | 5048.87 | -0.275 | -0.260
GOUSSET SOUDE | -672.5 | 4685 | 4898.87 | -0.680 | -0.665
GOUSSET SOUDE | -672.5 | 4685 | 5048.87 | -0.680 | -0.665
GOUSSET SOUDE | -267.5 | 4685 | 9183.87 | -0.275 | -0.260
GOUSSET SOUDE | -267.5 | 4685 | 9333.87 | -0.275 | -0.260
GOUSSET SOUDE | -672.5 | 4685 | 9183.87 | -0.680 | -0.665
GOUSSET SOUDE | -672.5 | 4685 | 9333.87 | -0.680 | -0.665
GOUSSET SOUDE | -267.5 | 4685 | 15183.9 | -0.275 | -0.260
GOUSSET SOUDE | -267.5 | 4685 | 15333.9 | -0.275 | -0.260
GOUSSET SOUDE | -672.5 | 4685 | 15183.9 | -0.680 | -0.665
GOUSSET SOUDE | -672.5 | 4685 | 15333.9 | -0.680 | -0.665
GOUSSET SOUDE | -267.5 | 4685 | 21183.9 | -0.275 | -0.260
GOUSSET SOUDE | -267.5 | 4685 | 21333.9 | -0.275 | -0.260
GOUSSET SOUDE | -672.5 | 4685 | 21183.9 | -0.680 | -0.665
GOUSSET SOUDE | -672.5 | 4685 | 21333.9 | -0.680 | -0.665
GOUSSET SOUDE | -267.5 | 4685 | 27183.9 | -0.275 | -0.260
GOUSSET SOUDE | -267.5 | 4685 | 27333.9 | -0.275 | -0.260
GOUSSET SOUDE | -672.5 | 4685 | 27183.9 | -0.680 | -0.665
GOUSSET SOUDE | -672.5 | 4685 | 27333.9 | -0.680 | -0.665
GOUSSET SOUDE | -267.5 | 4685 | 32083.9 | -0.275 | -0.260
GOUSSET SOUDE | -267.5 | 4685 | 32233.9 | -0.275 | -0.260
GOUSSET SOUDE | -672.5 | 4685 | 32083.9 | -0.680 | -0.665
GOUSSET SOUDE | -672.5 | 4685 | 32233.9 | -0.680 | -0.665
GOUSSET SOUDE | -267.5 | -8629.47 | 763.869 | -0.275 | -0.260
GOUSSET SOUDE | -672.5 | -8629.47 | 613.869 | -0.680 | -0.665
GOUSSET SOUDE | -672.5 | -8629.47 | 763.869 | -0.680 | -0.665
GOUSSET SOUDE | -267.5 | -8629.47 | 4898.87 | -0.275 | -0.260
GOUSSET SOUDE | -267.5 | -8629.47 | 5048.87 | -0.275 | -0.260
GOUSSET SOUDE | -672.5 | -8629.47 | 4898.87 | -0.680 | -0.665
GOUSSET SOUDE | -672.5 | -8629.47 | 5048.87 | -0.680 | -0.665
GOUSSET SOUDE | -267.5 | -8629.47 | 9183.87 | -0.275 | -0.260
GOUSSET SOUDE | -267.5 | -8629.47 | 9333.87 | -0.275 | -0.260
GOUSSET SOUDE | -672.5 | -8629.47 | 9183.87 | -0.680 | -0.665
GOUSSET SOUDE | -672.5 | -8629.47 | 9333.87 | -0.680 | -0.665
GOUSSET SOUDE | -267.5 | -7868.04 | 15183.9 | -0.275 | -0.260
GOUSSET SOUDE | -267.5 | -7868.04 | 15333.9 | -0.275 | -0.260
GOUSSET SOUDE | -672.5 | -7868.04 | 15183.9 | -0.680 | -0.665
GOUSSET SOUDE | -672.5 | -7868.04 | 15333.9 | -0.680 | -0.665
GOUSSET SOUDE | -267.5 | -7137.49 | 21183.9 | -0.275 | -0.260
GOUSSET SOUDE | -267.5 | -7137.49 | 21333.9 | -0.275 | -0.260
GOUSSET SOUDE | -672.5 | -7137.49 | 21183.9 | -0.680 | -0.665
GOUSSET SOUDE | -672.5 | -7137.49 | 21333.9 | -0.680 | -0.665
GOUSSET SOUDE | -267.5 | -6406.93 | 27183.9 | -0.275 | -0.260
GOUSSET SOUDE | -267.5 | -6406.93 | 27333.9 | -0.275 | -0.260
GOUSSET SOUDE | -672.5 | -6406.93 | 27183.9 | -0.680 | -0.665
GOUSSET SOUDE | -672.5 | -6406.93 | 27333.9 | -0.680 | -0.665
GOUSSET SOUDE | -267.5 | -5810.31 | 32083.9 | -0.275 | -0.260
GOUSSET SOUDE | -267.5 | -5810.31 | 32233.9 | -0.275 | -0.260
GOUSSET SOUDE | -672.5 | -5810.31 | 32083.9 | -0.680 | -0.665
GOUSSET SOUDE | -672.5 | -5810.31 | 32233.9 | -0.680 | -0.665

# IfcBeam: PL200*10750, MUR
In: Undefined
Description: PL200*10750; Material: /S275-E28
Tekla Common - Center of gravity Z: 3813.03 mm; Center of gravity Y: 2253.55 mm; Center of gravity X: 26125 mm; Bottom elevation: +3.326; Top elevation: +4.300; Part mark: MUR5; Assembly mark: MUR5; Phase: 1; Class: 0; Grade: S275-E28; Profile: PL200*10750; Name: MUR; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 11.9862 m3; Gross volume: 11.9862 m3; Gross footprint area: 0 m2; Net surface area: 126.392 m2; Gross area: 126.392 m2; Height: 10750 mm; Width: 200 mm; Length: 5575 mm; sets with these values: 2
BaseQuantities - Length: 5575 mm; OuterSurfaceArea: 126.392 m2; NetVolume: 11.9862 m3; NetWeight: 0 kg

# IfcBeam: PL200*4800 (3)
In: Undefined
Description: PL200*4800; Material: /S275-E28
Tekla Common - Bottom elevation: +0.000; Top elevation: +4.800; Phase: 1; Class: 0; Grade: S275-E28; Profile: PL200*4800; Name: MUR; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Height: 4800 mm; Width: 200 mm; sets with these values: 2
BaseQuantities - NetWeight: 0 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark = Assembly mark | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Gross area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
MUR | 2400 | -1897.23 | 319.426 | MUR2 | 13.248 | 13.248 | 2.76 | 139.92 | 139.92 | 13800
MUR | 2149.95 | 5100 | 4665.35 | MUR3 | 8.54124 | 9.7344 | 0.724 | 91.0728 | 103.32 | 10140
MUR | 2400 | 5100 | 21255 | MUR4 | 21.3408 | 21.3408 | 4.446 | 224.22 | 224.22 | 22230

# IfcBeam: PL200*5800, MUR
In: Undefined
Description: PL200*5800; Material: /S275-E28
Tekla Common - Center of gravity Z: 2900 mm; Center of gravity Y: -1750.72 mm; Center of gravity X: 16.8744 mm; Bottom elevation: +0.000; Top elevation: +5.800; Part mark: MUR1; Assembly mark: MUR1; Phase: 1; Class: 0; Grade: S275-E28; Profile: PL200*5800; Name: MUR; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 15.66 m3; Gross volume: 15.66 m3; Gross footprint area: 2.7 m2; Net surface area: 164.32 m2; Gross area: 164.32 m2; Height: 5800 mm; Width: 200 mm; Length: 13500 mm; sets with these values: 2
BaseQuantities - Length: 13500 mm; OuterSurfaceArea: 164.32 m2; NetVolume: 15.66 m3; NetWeight: 0 kg

# IfcBeam: PL200*865, GOUSSET
In: Undefined
Description: PL200*865; Material: /S235-E24
Tekla Common - Center of gravity Z: 5088.27 mm; Center of gravity Y: 5100 mm; Center of gravity X: 1565.91 mm; Bottom elevation: +4.800; Top elevation: +5.665; Part mark: G10; Assembly mark: G10; Phase: 1; Class: 0; Grade: S235-E24; Profile: PL200*865; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.266455 m3; Gross volume: 0.266455 m3; Gross footprint area: 0 m2; Net surface area: 4.09377 m2; Gross area: 2.66455 m2; Height: 864.796 mm; Width: 200 mm; Length: 3081.13 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
BaseQuantities - Length: 3081.13 mm; OuterSurfaceArea: 4.09377 m2; NetVolume: 0.266455 m3; NetWeight: 0 kg

# IfcBeam: PL35*4300, GOUSSET
In: Undefined
Description: PL35*4300; Material: /S235-E24
Tekla Common - Center of gravity Z: 1962.44 mm; Center of gravity Y: 2330.87 mm; Center of gravity X: 31343 mm; Bottom elevation: -0.000; Top elevation: +4.300; Part mark: G1; Assembly mark: G1; Phase: 1; Class: 0; Grade: S235-E24; Profile: PL35*4300; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.755911 m3; Gross volume: 0.755911 m3; Gross footprint area: 0 m2; Net surface area: 43.8571 m2; Gross area: 23.7392 m2; Height: 4300 mm; Width: 35 mm; Length: 5520.74 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
BaseQuantities - Length: 5520.74 mm; OuterSurfaceArea: 43.8571 m2; NetVolume: 0.755911 m3; NetWeight: 0 kg

# IfcBeam: PL4*1090, GOUSSET
In: Undefined
Description: PL4*1090; Material: /S275-E28
Tekla Common - Center of gravity Z: 3545 mm; Center of gravity Y: -8052.39 mm; Center of gravity X: 15257.9 mm; Bottom elevation: +3.000; Top elevation: +4.090; Part mark: MTP1; Assembly mark: MTP1; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL4*1090; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.000943692 m3; Gross volume: 0.000943692 m3; Gross footprint area: 0.000865773 m2; Net surface area: 0.482298 m2; Gross area: 0.482298 m2; Height: 1090 mm; Width: 4 mm; Length: 200.384 mm; sets with these values: 2
BaseQuantities - Length: 200.384 mm; OuterSurfaceArea: 0.482298 m2; NetVolume: 0.000943692 m3; NetWeight: 0 kg

# IfcBeam: PL4*1100 (2)
In: Undefined
Description: PL4*1100; Material: /S275-E28
Tekla Common - Center of gravity Z: 3550 mm; Bottom elevation: +3.000; Top elevation: +4.100; Part mark: MTP2; Assembly mark: MTP2; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL4*1100; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.00095235 m3; Gross volume: 0.00095235 m3; Gross footprint area: 0.000865773 m2; Net surface area: 0.486706 m2; Gross area: 0.486706 m2; Height: 1100 mm; Width: 4 mm; Length: 200.384 mm; sets with these values: 2
BaseQuantities - Length: 200.384 mm; OuterSurfaceArea: 0.486706 m2; NetVolume: 0.00095235 m3; NetWeight: 0 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm)
GOUSSET | -6591.27 | 27257.9
GOUSSET | -7321.83 | 21257.9

# IfcBeam: PL4*1150, GOUSSET
In: Undefined
Description: PL4*1150; Material: /S275-E28
Tekla Common - Center of gravity Z: 3575 mm; Center of gravity Y: -5994.65 mm; Center of gravity X: 32157.9 mm; Bottom elevation: +3.000; Top elevation: +4.150; Part mark: MTP3; Assembly mark: MTP3; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL4*1150; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.000995638 m3; Gross volume: 0.000995638 m3; Gross footprint area: 0.000865773 m2; Net surface area: 0.508751 m2; Gross area: 0.508751 m2; Height: 1150 mm; Width: 4 mm; Length: 200.384 mm; sets with these values: 2
BaseQuantities - Length: 200.384 mm; OuterSurfaceArea: 0.508751 m2; NetVolume: 0.000995638 m3; NetWeight: 0 kg

# IfcBeam: PL4*1650 (2)
In: Undefined
Description: PL4*1650; Material: /S275-E28
Tekla Common - Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL4*1650; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Height: 1650 mm; Width: 4 mm; sets with these values: 2
BaseQuantities - NetWeight: 0 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Gross area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
GOUSSET | 3848.04 | -5955.26 | 32276.6 | +3.025 | +4.675 | 135 | P13 | 0.00124766 | 0.00126151 | 0.00076455 | 0.639469 | 0.645483 | 187.137
GOUSSET | 3823.42 | -8780.49 | 9378.64 | +3.000 | +4.650 | 127 | P6 | 0.00117289 | 0.00118028 | 0.000715323 | 0.601517 | 0.604772 | 178.588

# IfcBeam: PL4*3000 (7)
In: Undefined
Description: PL4*3000; Material: /S275-E28
Tekla Common - Center of gravity Z: 1500 mm; Top elevation: +3.000; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL4*3000; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Height: 3000 mm; Width: 4 mm; sets with these values: 2
BaseQuantities - NetWeight: 0 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Part mark | Assembly mark | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
GOUSSET | -6591.27 | 27257.9 | +0.000 | MTP4 | MTP4 | 0.00259732 | 0.000865773 | 1.32439 | 200.384
GOUSSET | -5994.65 | 32157.9 | -0.000 | MTP4 | MTP4 | 0.00259732 | 0.000865773 | 1.32439 | 200.384
GOUSSET | 4829.4 | 32282.3 | -0.000 | 130 | P8 | 0.00212709 | 0.00070903 | 1.08896 | 173.257
GOUSSET | -5955.33 | 32275.9 | -0.000 | 136 | P13 | 0.00229365 | 0.00076455 | 1.17235 | 187.137
GOUSSET | -7321.83 | 21257.9 | -0.000 | MTP4 | MTP4 | 0.00259732 | 0.000865773 | 1.32439 | 200.384
GOUSSET | -8052.39 | 15257.9 | +0.000 | MTP4 | MTP4 | 0.00259732 | 0.000865773 | 1.32439 | 200.384
GOUSSET | -8780.49 | 9378.25 | +0.000 | 128 | P6 | 0.00214597 | 0.000715323 | 1.09842 | 178.588

# IfcBeam: PL4*500, GOUSSET
In: Undefined
Description: PL4*500; Material: /S275-E28
Tekla Common - Center of gravity Z: 3250 mm; Center of gravity Y: 4829.4 mm; Center of gravity X: 32282.3 mm; Bottom elevation: +3.000; Top elevation: +3.500; Part mark: 129; Assembly mark: P8; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL4*500; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.000354515 m3; Gross volume: 0.000354515 m3; Gross footprint area: 0.00070903 m2; Net surface area: 0.182676 m2; Gross area: 0.182676 m2; Height: 500 mm; Width: 4 mm; Length: 173.257 mm; sets with these values: 2
BaseQuantities - Length: 173.257 mm; OuterSurfaceArea: 0.182676 m2; NetVolume: 0.000354515 m3; NetWeight: 0 kg

# IfcBeam: PL5*100 (2)
In: Undefined
Description: PL5*100; Material: /S235-E24
Tekla Common - Center of gravity Y: 5050 mm; Top elevation: +4.700; Phase: 2; Class: 5; Grade: S235-E24; Profile: PL5*100; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Height: 100 mm; Width: 5 mm; sets with these values: 2
BaseQuantities - NetWeight: 0 kg
Name | Center of gravity Z (mm) | Center of gravity X (mm) | Bottom elevation | Part mark = Assembly mark | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
GOUSSET | 4632.42 | 4302.17 | +4.572 | ATP4 | 0.000156938 | 0.00625 | 0.066914 | 305.086
GOUSSET | 4620.59 | 10130.7 | +4.497 | ATP3 | 0.00013 | 0.00624978 | 0.0556 | 255.004

# IfcBeam: PL5*120 (31)
In: Undefined
Description: PL5*120; Material: /S275-E28
Tekla Common - Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL5*120; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Height: 120 mm; Width: 5 mm; sets with these values: 2
BaseQuantities - NetWeight: 0 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark = Assembly mark | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
GOUSSET | 4324.71 | -3278.51 | 32158.9 | +4.272 | +4.383 | EC3 | 0.000123301 | 0 | 0.0525756 | 196.358
GOUSSET | 4262.78 | -5047.9 | 32158.9 | +4.210 | +4.321 | EC3 | 0.000123301 | 0 | 0.0525756 | 196.358
GOUSSET | 4138.91 | 4642.21 | 32158.9 | +4.086 | +4.197 | EC4 | 0.000123301 | 0 | 0.0525756 | 196.358
GOUSSET | 4324.71 | -665.969 | 32158.9 | +4.272 | +4.383 | EC3 | 0.000123301 | 0 | 0.0525756 | 196.358
GOUSSET | 4262.78 | 1103.42 | 32158.9 | +4.210 | +4.321 | EC3 | 0.000123301 | 0 | 0.0525756 | 196.358
GOUSSET | 4200.85 | 2872.82 | 32158.9 | +4.148 | +4.259 | EC3 | 0.000123301 | 0 | 0.0525756 | 196.358
GOUSSET | 4370.58 | -1999.59 | 32158.9 | +4.317 | +4.427 | EC5 | 0.000125726 | 0.00578854 | 0.0535859 | 200.503
GOUSSET | 4370.58 | -1944.89 | 32158.9 | +4.317 | +4.427 | EC5 | 0.000125726 | 0.00578854 | 0.0535859 | 200.503
GOUSSET | 4370.58 | -1999.59 | 27258.9 | +4.317 | +4.427 | EC5 | 0.000125726 | 0.00578854 | 0.0535859 | 200.503
GOUSSET | 4370.58 | -1944.89 | 27258.9 | +4.317 | +4.427 | EC5 | 0.000125726 | 0.00578854 | 0.0535859 | 200.503
GOUSSET | 4370.58 | -1999.59 | 4973.87 | +4.317 | +4.427 | EC5 | 0.000125726 | 0.00578854 | 0.0535859 | 200.503
GOUSSET | 4370.58 | -1944.89 | 4973.87 | +4.317 | +4.427 | EC5 | 0.000125726 | 0.00578854 | 0.0535859 | 200.503
GOUSSET | 4370.58 | -1999.59 | 688.868 | +4.317 | +4.427 | EC5 | 0.000125726 | 0.00578854 | 0.0535859 | 200.503
GOUSSET | 4370.58 | -1944.89 | 688.868 | +4.317 | +4.427 | EC5 | 0.000125726 | 0.00578854 | 0.0535859 | 200.503
GOUSSET | 4138.92 | -8586.69 | 4973.87 | +4.086 | +4.197 | EC3 | 0.000123301 | 0 | 0.0525756 | 196.358
GOUSSET | 4138.91 | -8586.69 | 688.868 | +4.086 | +4.197 | EC3 | 0.000123301 | 0 | 0.0525756 | 196.358
GOUSSET | 4324.71 | -3278.51 | 4973.87 | +4.272 | +4.383 | EC3 | 0.000123301 | 0 | 0.0525756 | 196.358
GOUSSET | 4324.71 | -3278.51 | 688.868 | +4.272 | +4.383 | EC3 | 0.000123301 | 0 | 0.0525756 | 196.358
GOUSSET | 4262.78 | -5047.9 | 4973.87 | +4.210 | +4.321 | EC3 | 0.000123301 | 0 | 0.0525756 | 196.358
GOUSSET | 4262.78 | -5047.9 | 688.868 | +4.210 | +4.321 | EC3 | 0.000123301 | 0 | 0.0525756 | 196.358
GOUSSET | 4200.85 | -6817.3 | 4973.87 | +4.148 | +4.259 | EC3 | 0.000123301 | 0 | 0.0525756 | 196.358
GOUSSET | 4200.85 | -6817.3 | 688.868 | +4.148 | +4.259 | EC3 | 0.000123301 | 0 | 0.0525756 | 196.358
GOUSSET | 4138.92 | 4642.21 | 4973.87 | +4.086 | +4.197 | EC7 | 0.000123301 | 0 | 0.0525756 | 196.358
GOUSSET | 4138.91 | 4642.21 | 688.868 | +4.086 | +4.197 | EC3 | 0.000123301 | 0 | 0.0525756 | 196.358
GOUSSET | 4324.71 | -665.969 | 4973.87 | +4.272 | +4.383 | EC3 | 0.000123301 | 0 | 0.0525756 | 196.358
GOUSSET | 4324.71 | -665.969 | 688.868 | +4.272 | +4.383 | EC3 | 0.000123301 | 0 | 0.0525756 | 196.358
GOUSSET | 4262.78 | 1103.42 | 4973.87 | +4.210 | +4.321 | EC3 | 0.000123301 | 0 | 0.0525756 | 196.358
GOUSSET | 4262.78 | 1103.42 | 688.868 | +4.210 | +4.321 | EC3 | 0.000123301 | 0 | 0.0525756 | 196.358
GOUSSET | 4200.85 | 2872.82 | 4973.87 | +4.148 | +4.259 | EC3 | 0.000123301 | 0 | 0.0525756 | 196.358
GOUSSET | 4200.85 | 2872.82 | 688.868 | +4.148 | +4.259 | EC3 | 0.000123301 | 0 | 0.0525756 | 196.358
GOUSSET | 4237.6 | -5767.33 | 32162.1 | +4.185 | +4.296 | EC3 | 0.000123301 | 0 | 0.0525756 | 196.358

# IfcBeam: PL5*188, GOUSSET
In: Undefined
Description: PL5*188; Material: /S235-E24
Tekla Common - Center of gravity Z: 4277.78 mm; Center of gravity Y: -1972.68 mm; Center of gravity X: 7116.37 mm; Bottom elevation: +4.275; Top elevation: +4.280; Part mark: G3; Assembly mark: G3; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S235-E24; Profile: PL5*188; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.000254477 m3; Gross volume: 0.000254477 m3; Gross footprint area: 0.0508955 m2; Net surface area: 0.106156 m2; Gross area: 0.0523034 m2; Height: 188.056 mm; Width: 5 mm; Length: 278.126 mm; sets with these values: 2
Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
BaseQuantities - Length: 278.126 mm; OuterSurfaceArea: 0.106156 m2; NetVolume: 0.000254477 m3; NetWeight: 0 kg

# IfcBeam: PL5*245 (2)
In: Undefined
Description: PL5*245; Material: /S235-E24
Tekla Common - Center of gravity Z: 4184.9 mm; Center of gravity X: 7116.44 mm; Bottom elevation: +4.177; Top elevation: +4.192; Part mark: G4; Assembly mark: G4; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S235-E24; Profile: PL5*245; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.000346743 m3; Gross volume: 0.000346743 m3; Gross footprint area: 0 m2; Net surface area: 0.143717 m2; Gross area: 0.071028 m2; Height: 244.946 mm; Width: 5 mm; Length: 289.975 mm; sets with these values: 2
BaseQuantities - Length: 289.975 mm; OuterSurfaceArea: 0.143717 m2; NetVolume: 0.000346743 m3; NetWeight: 0 kg
Name | Center of gravity Y (mm)
GOUSSET | 1959.43 | Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
GOUSSET | -5903.89

# IfcBeam: PL5*252 (4)
In: Undefined
Description: PL5*252; Material: /S235-E24
Tekla Common - Center of gravity Z: 4094.48 mm; Bottom elevation: +4.086; Top elevation: +4.102; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S235-E24; Profile: PL5*252; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.000307185 m3; Gross volume: 0.000307185 m3; Gross footprint area: 0 m2; Net surface area: 0.127875 m2; Gross area: 0.0742213 m2; Height: 251.954 mm; Width: 5 mm; Length: 294.583 mm; sets with these values: 2
BaseQuantities - Length: 294.583 mm; OuterSurfaceArea: 0.127875 m2; NetVolume: 0.000307185 m3; NetWeight: 0 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark = Assembly mark
GOUSSET | 4542.88 | 9232.86 | G7
GOUSSET | -8487.34 | 9232.86 | G8 | Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
GOUSSET | -8487.34 | 4999.88 | G7
GOUSSET | 4542.88 | 4999.88 | G6

# IfcBeam: PL5*289 (4)
In: Undefined
Description: PL5*289; Material: /S235-E24
Tekla Common - Center of gravity Z: 4277.41 mm; Bottom elevation: +4.268; Top elevation: +4.285; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S235-E24; Profile: PL5*289; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.00038079 m3; Gross volume: 0.00038079 m3; Gross footprint area: 0 m2; Net surface area: 0.157768 m2; Gross area: 0.102825 m2; Height: 289.045 mm; Width: 5 mm; Length: 355.74 mm; sets with these values: 2
BaseQuantities - Length: 355.74 mm; OuterSurfaceArea: 0.157768 m2; NetVolume: 0.00038079 m3; NetWeight: 0 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark = Assembly mark
GOUSSET | -3260.51 | 9180.42 | G5 | Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
GOUSSET | -3260.51 | 5052.32 | G9
GOUSSET | -683.945 | 9180.42 | G5
GOUSSET | -683.945 | 5052.32 | G5

# IfcBeam: PL5*380 (2)
In: Undefined
Description: PL5*380; Material: /S275-E28
Tekla Common - Bottom elevation: +4.086; Assembly mark: EC1; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL5*380; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Gross volume: 0.000390455 m3; Gross footprint area: 0 m2; Gross area: 0.162037 m2; Height: 370 mm; Width: 5 mm; Length: 196.358 mm; sets with these values: 2
BaseQuantities - Length: 196.358 mm; NetWeight: 0 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Top elevation | Part mark | Net volume (m3) = NetVolume (m3) | Net surface area (m2) = OuterSurfaceArea (m2)
GOUSSET | 4138.83 | -8586.78 | 9077.36 | +4.197 | 114 | 0.000376379 | 0.156295
GOUSSET | 4139.61 | -8564.4 | 9442.3 | +4.198 | 113 | 0.000376381 | 0.156296

# IfcBeam: PL5*50 (8)
In: Undefined
Description: PL5*50; Material: /S235-E24
Tekla Common - Part mark: 146; Assembly mark: K23; Phase: 2; Class: 5; Grade: S235-E24; Profile: PL5*50; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.0000312714 m3; Gross volume: 0.0000312714 m3; Gross footprint area: 0 m2; Net surface area: 0.0142594 m2; Gross area: 0.00625429 m2; Height: 50 mm; Width: 5 mm; Length: 125.086 mm; sets with these values: 2
BaseQuantities - Length: 125.086 mm; OuterSurfaceArea: 0.0142594 m2; NetVolume: 0.0000312714 m3; NetWeight: 0 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation
GOUSSET | 4397.86 | -3249.72 | 28641.4 | +4.393 | +4.403 | Tekla Status - Erection Comment: Missing Value; Checked Date: 0; Assigned By: Me; sets with these values: 2
GOUSSET | 4441.36 | -2036.71 | 28641.4 | +4.437 | +4.446
GOUSSET | 4397.86 | -754.626 | 28641.4 | +4.393 | +4.403
GOUSSET | 4441.36 | -1967.64 | 28641.4 | +4.437 | +4.446
GOUSSET | 4397.86 | -3249.72 | 3641.37 | +4.393 | +4.403
GOUSSET | 4441.36 | -2036.71 | 3641.37 | +4.437 | +4.446
GOUSSET | 4397.86 | -754.626 | 3641.37 | +4.393 | +4.403
GOUSSET | 4441.36 | -1967.64 | 3641.37 | +4.437 | +4.446
