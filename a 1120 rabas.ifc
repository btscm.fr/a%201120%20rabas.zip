Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcBeam: PL5*60 (20)
In: Undefined
Description: PL5*60; Material: /S275-E28
Tekla Common - Bottom elevation: +4.575; Top elevation: +4.700; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL5*60; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Height: 60 mm; Width: 5 mm; sets with these values: 2
BaseQuantities - NetWeight: 0 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark = Assembly mark | Net volume (m3) = Gross volume (m3) = NetVolume (m3) | Gross footprint area (m2) | Net surface area (m2) = Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
GOUSSET | 4656.4 | -7289.85 | 21272.4 | ATP1 | 0.00005475 | 0.00375 | 0.024325 | 177.5
GOUSSET | 4656.4 | -7293.44 | 21242.9 | ATP1 | 0.00005475 | 0.00375 | 0.024325 | 177.5
GOUSSET | 4656.4 | -8023.94 | 15242.9 | ATP1 | 0.00005475 | 0.00375 | 0.024325 | 177.5
GOUSSET | 4656.4 | -8744.47 | 674.022 | ATP1 | 0.00005475 | 0.00375 | 0.024325 | 177.5
GOUSSET | 4656.4 | -8744.47 | 703.713 | ATP1 | 0.00005475 | 0.00375 | 0.024325 | 177.5
GOUSSET | 4656.4 | -8744.53 | 4959.02 | ATP1 | 0.00005475 | 0.00375 | 0.024325 | 177.5
GOUSSET | 4656.4 | -8744.53 | 4988.71 | ATP1 | 0.00005475 | 0.00375 | 0.024325 | 177.5
GOUSSET | 4656.4 | -8744.47 | 9244.02 | ATP1 | 0.00005475 | 0.00375 | 0.024325 | 177.5
GOUSSET | 4656.4 | -8744.47 | 9273.71 | ATP1 | 0.00005475 | 0.00375 | 0.024325 | 177.5
GOUSSET | 4656.4 | -8020.36 | 15272.4 | ATP1 | 0.00005475 | 0.00375 | 0.024325 | 177.5
GOUSSET | 4656.4 | -6562.88 | 27242.9 | ATP1 | 0.00005475 | 0.00375 | 0.024325 | 177.5
GOUSSET | 4656.4 | -6559.29 | 27272.4 | ATP1 | 0.00005475 | 0.00375 | 0.024325 | 177.5
GOUSSET | 4656.4 | -5966.21 | 32142.9 | ATP1 | 0.00005475 | 0.00375 | 0.024325 | 177.5
GOUSSET | 4670.95 | -5958.33 | 32207.6 | ATP2 | 0.00008475 | 0.00975 | 0.037325 | 277.5
GOUSSET | 4656.4 | -4205.21 | 32280 | ATP1 | 0.00005475 | 0.00375 | 0.024325 | 177.5
GOUSSET | 4656.4 | -4175.52 | 32280 | ATP1 | 0.00005475 | 0.00375 | 0.024325 | 177.5
GOUSSET | 4656.4 | -175.21 | 32280 | ATP1 | 0.00005475 | 0.00375 | 0.024325 | 177.5
GOUSSET | 4656.4 | -145.518 | 32280 | ATP1 | 0.00005475 | 0.00375 | 0.024325 | 177.5
GOUSSET | 4656.4 | 4735.09 | 32280 | ATP1 | 0.00005475 | 0.00375 | 0.024325 | 177.5
GOUSSET | 4656.4 | 4764.79 | 32280 | ATP1 | 0.00005475 | 0.00375 | 0.024325 | 177.5

# IfcBeam: PL5*720 (30)
In: Undefined
Description: PL5*720; Material: /S275-E28
Tekla Common - Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL5*720; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.000739809 m3; Gross volume: 0.000739809 m3; Gross footprint area: 0 m2; Net surface area: 0.305179 m2; Gross area: 0.305179 m2; Height: 720 mm; Width: 5 mm; Length: 196.358 mm; sets with these values: 2
BaseQuantities - Length: 196.358 mm; OuterSurfaceArea: 0.305179 m2; NetVolume: 0.000739809 m3; NetWeight: 0 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark = Assembly mark | Phase
GOUSSET | 4324.71 | -3278.5 | 27258.9 | +4.272 | +4.383 | EC2 | 1
GOUSSET | 4262.78 | -5047.89 | 27258.9 | +4.210 | +4.321 | EC2 | 1
GOUSSET | 4138.92 | 4642.23 | 27258.9 | +4.086 | +4.197 | EC2 | 1
GOUSSET | 4324.71 | -665.969 | 27258.9 | +4.272 | +4.383 | EC2 | 1
GOUSSET | 4262.78 | 1103.42 | 27258.9 | +4.210 | +4.321 | EC2 | 1
GOUSSET | 4200.85 | 2872.82 | 27258.9 | +4.148 | +4.259 | EC2 | 1
GOUSSET | 4324.71 | -3278.5 | 21258.9 | +4.272 | +4.383 | EC2 | 1
GOUSSET | 4262.78 | -5047.89 | 21258.9 | +4.210 | +4.321 | EC2 | 1
GOUSSET | 4200.85 | -6817.29 | 21258.9 | +4.148 | +4.259 | EC2 | 1
GOUSSET | 4138.92 | 4642.23 | 21258.9 | +4.086 | +4.197 | EC2 | 1
GOUSSET | 4324.71 | -665.969 | 21258.9 | +4.272 | +4.383 | EC2 | 1
GOUSSET | 4262.78 | 1103.42 | 21258.9 | +4.210 | +4.321 | EC2 | 1
GOUSSET | 4200.85 | 2872.82 | 21258.9 | +4.148 | +4.259 | EC2 | 1
GOUSSET | 4324.71 | -3278.5 | 15258.9 | +4.272 | +4.383 | EC2 | 1
GOUSSET | 4262.78 | -5047.89 | 15258.9 | +4.210 | +4.321 | EC2 | 1
GOUSSET | 4200.85 | -6817.29 | 15258.9 | +4.148 | +4.259 | EC2 | 1
GOUSSET | 4138.92 | 4642.23 | 15258.9 | +4.086 | +4.197 | EC2 | 1
GOUSSET | 4324.71 | -665.969 | 15258.9 | +4.272 | +4.383 | EC2 | 1
GOUSSET | 4262.78 | 1103.42 | 15258.9 | +4.210 | +4.321 | EC2 | 1
GOUSSET | 4200.85 | 2872.82 | 15258.9 | +4.148 | +4.259 | EC2 | 1
GOUSSET | 4324.71 | -3278.5 | 9258.87 | +4.272 | +4.383 | EC2 | 1
GOUSSET | 4262.78 | -5047.89 | 9258.87 | +4.210 | +4.321 | EC2 | 1
GOUSSET | 4200.85 | -6817.29 | 9258.87 | +4.148 | +4.259 | EC2 | 1
GOUSSET | 4138.92 | 4642.23 | 9258.87 | +4.086 | +4.197 | EC2 | 1
GOUSSET | 4324.71 | -665.969 | 9258.87 | +4.272 | +4.383 | EC6 | 1
GOUSSET | 4262.78 | 1103.42 | 9258.87 | +4.210 | +4.321 | EC2 | 6
GOUSSET | 4200.85 | 2872.82 | 9258.87 | +4.148 | +4.259 | EC2 | 1
GOUSSET | 4216.49 | -6370.55 | 27262.1 | +4.162 | +4.276 | EC2 | 1
GOUSSET | 4190.63 | -7109.19 | 21262.1 | +4.137 | +4.250 | EC2 | 1
GOUSSET | 4164.78 | -7847.84 | 15262.1 | +4.111 | +4.224 | EC2 | 1

# IfcBeam: PL6*252 (14)
In: Undefined
Description: PL6*252; Material: /S275-E28
Tekla Common - Part mark: 80; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL6*252; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.00115998 m3; Gross volume: 0.00115998 m3; Gross footprint area: 0 m2; Net surface area: 0.405831 m2; Gross area: 0.375128 m2; Height: 252.138 mm; Width: 6 mm; Length: 1487.79 mm; sets with these values: 2
BaseQuantities - Length: 1487.79 mm; OuterSurfaceArea: 0.405831 m2; NetVolume: 0.00115998 m3; NetWeight: 0 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Assembly mark
GOUSSET | 3753.66 | 4011.83 | 4973.87 | +3.566 | +3.874 | T1
GOUSSET | 3753.66 | -7956.42 | 4973.87 | +3.566 | +3.874 | T1
GOUSSET | 3753.66 | -7956.42 | 688.868 | +3.566 | +3.874 | T10
GOUSSET | 3753.66 | 4011.83 | 688.868 | +3.566 | +3.874 | T10
GOUSSET | 3753.66 | 4011.83 | 9258.87 | +3.566 | +3.874 | T2
GOUSSET | 3753.66 | 4011.83 | 15258.9 | +3.566 | +3.874 | T3
GOUSSET | 3753.66 | 4011.83 | 27258.9 | +3.566 | +3.874 | T10
GOUSSET | 3753.66 | 4011.83 | 21258.9 | +3.566 | +3.874 | T3
GOUSSET | 3753.66 | -7956.42 | 9258.87 | +3.566 | +3.874 | T8
GOUSSET | 3780.3 | -7195.05 | 15258.9 | +3.592 | +3.901 | T4
GOUSSET | 3805.87 | -6464.49 | 21258.9 | +3.618 | +3.926 | T5
GOUSSET | 3831.44 | -5733.93 | 27258.9 | +3.644 | +3.952 | T6
GOUSSET | 3852.32 | -5137.31 | 32158.9 | +3.665 | +3.973 | T9
GOUSSET | 3753.66 | 4011.83 | 32158.9 | +3.566 | +3.874 | T7

# IfcBeam: PL8*130 (2)
In: Undefined
Description: PL8*130; Material: /S275-E28
Tekla Common - Center of gravity Z: 3926 mm; Center of gravity X: 32230 mm; Bottom elevation: +3.922; Top elevation: +3.930; Part mark: 14; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL8*130; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.000208 m3; Gross volume: 0.000208 m3; Gross footprint area: 0.026 m2; Net surface area: 0.05728 m2; Gross area: 0.05728 m2; Height: 130 mm; Width: 8 mm; Length: 200 mm; sets with these values: 2
BaseQuantities - Length: 200 mm; OuterSurfaceArea: 0.05728 m2; NetVolume: 0.000208 m3; NetWeight: 0 kg
Name | Center of gravity Y (mm) | Assembly mark
GOUSSET | -160.364 | M4
GOUSSET | -4190.37 | M5

# IfcBeam: PL8*150, GOUSSET
In: Undefined
Description: PL8*150; Material: /S275-E28
Tekla Common - Center of gravity Z: 4082.99 mm; Center of gravity Y: 4684.94 mm; Center of gravity X: 32158.9 mm; Bottom elevation: +4.073; Top elevation: +4.093; Part mark: 13; Assembly mark: P8; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL8*150; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.000383906 m3; Gross volume: 0.000383906 m3; Gross footprint area: 0 m2; Net surface area: 0.103495 m2; Gross area: 0.103495 m2; Height: 150 mm; Width: 8 mm; Length: 319.922 mm; sets with these values: 2
BaseQuantities - Length: 319.922 mm; OuterSurfaceArea: 0.103495 m2; NetVolume: 0.000383906 m3; NetWeight: 0 kg

# IfcBeam: PL8*160 (9)
In: Undefined
Description: PL8*160; Material: /S275-E28
Tekla Common - Center of gravity Z: 4082.99 mm; Bottom elevation: +4.073; Top elevation: +4.093; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL8*160; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.0004095 m3; Gross volume: 0.0004095 m3; Gross footprint area: 0 m2; Net surface area: 0.110054 m2; Gross area: 0.110054 m2; Height: 160 mm; Width: 8 mm; Length: 319.922 mm; sets with these values: 2
BaseQuantities - Length: 319.922 mm; OuterSurfaceArea: 0.110054 m2; NetVolume: 0.0004095 m3; NetWeight: 0 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm) | Part mark | Assembly mark
GOUSSET | 4684.94 | 27258.9 | 11 | P7
GOUSSET | 4684.94 | 21258.9 | 11 | P7
GOUSSET | 4684.94 | 4973.87 | 10 | P3
GOUSSET | -8629.53 | 9258.87 | 12 | P6
GOUSSET | -8629.53 | 4973.87 | 11 | P5
GOUSSET | 4685 | 688.868 | 11 | P7
GOUSSET | -8629.47 | 688.868 | 11 | P9
GOUSSET | 4684.94 | 9258.87 | 11 | P4
GOUSSET | 4684.94 | 15258.9 | 11 | P7

# IfcBeam: TUBE-C-100*100*3 (10)
In: Undefined
Description: TUBE-C-100*100*3; Material: /S275-E28
Tekla Common - Grade: S275-E28; Profile: TUBE-C-100*100*3; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Height: 100 mm; Width: 100 mm; sets with these values: 2
BaseQuantities - NetWeight: 0 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Class | Name | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Finish
LISSE | 4750 | 5050 | 6980 | +4.700 | +4.800 | L17 | L17 | 2 | 5 | LISSE | 0.00782208 | 0.0076608 | 0.672 | 2.6892 | 2.6208 | 6720
LISSE | 4750 | -6263.1 | 29710.1 | +4.700 | +4.800 | L6 | L6 | 1 | 1 | LISSE | 0.0057399 | 0.00562156 | 0.493119 | 1.97368 | 1.92316 | 4931.19 | ANTI-BLEU
LISSE | 4750 | -6926.99 | 24257.6 | +4.700 | +4.800 | L5 | L5 | 1 | 1 | LISSE | 0.00702394 | 0.00687912 | 0.603431 | 2.41493 | 2.35338 | 6034.31 | ANTI-BLEU
LISSE | 4750 | -7657.55 | 18257.6 | +4.700 | +4.800 | L5 | L5 | 1 | 1 | LISSE | 0.00702394 | 0.00687912 | 0.603431 | 2.41493 | 2.35338 | 6034.31 | ANTI-BLEU
LISSE | 4750 | -8387.84 | 12259.8 | +4.700 | +4.800 | L4 | L4 | 1 | 1 | LISSE | 0.00701879 | 0.00687407 | 0.602989 | 2.41316 | 2.35166 | 6029.89 | ANTI-BLEU
LISSE | 4750 | -8744.47 | 7116.37 | +4.700 | +4.800 | L3 | L3 | 1 | 1 | LISSE | 0.0049761 | 0.0048735 | 0.4275 | 1.7112 | 1.66725 | 4275 | ANTI-BLEU
LISSE | 4750 | -8744.47 | 2763.87 | +4.700 | +4.800 | L2 | L2 | 1 | 1 | LISSE | 0.00513324 | 0.0050274 | 0.441 | 1.7652 | 1.7199 | 4410 | ANTI-BLEU
LISSE | 4750 | -489.68 | 32280 | +4.700 | +4.800 | L1 | L1 | 1 | 1 | LISSE | 0.0127707 | 0.0125074 | 1.09714 | 4.38975 | 4.27883 | 10971.4 | ANTI-BLEU
BUTON | 3934.72 | -8694.59 | 7116.37 | +3.885 | +3.985 | 65 | B1 | 1 | 1 | BUTON | 0.00495981 | 0.00485755 | 0.4261 | 1.7056 | 1.66179 | 4261 | ANTI-BLEU
BUTON | 3934.72 | 4750 | 7116.37 | +3.885 | +3.985 | 65 | B1 | 1 | 1 | BUTON | 0.00495981 | 0.00485755 | 0.4261 | 1.7056 | 1.66179 | 4261 | ANTI-BLEU

# IfcBeam: UPF-100*50*3 (2)
In: Undefined
Description: UPF-100*50*3; Material: /S275-E28
Tekla Common - Center of gravity X: 32280 mm; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: UPF-100*50*3; Name: MONTANT; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Gross area: 0 m2; Height: 100 mm; Width: 50 mm; sets with these values: 2
BaseQuantities - NetWeight: 0 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
MONTANT | 2113.61 | -4952.87 | +2.100 | +2.150 | 67 | M2 | 0.00080025 | 0.000784162 | 0.00825 | 0.542914 | 1375
MONTANT | 1025 | -5488.98 | -0.045 | +2.095 | 66 | M1 | 0.00124548 | 0.00122044 | 0.000582 | 0.844324 | 2140

# IfcBeam: UPF-100*50*4 (4)
In: Undefined
Description: UPF-100*50*4; Material: /S275-E28
Tekla Common - Center of gravity Z: 4367.15 mm; Bottom elevation: +4.296; Top elevation: +4.439; Part mark: 147; Assembly mark: K23; Phase: 2; Class: 5; Finish: ANTI-BLEU; Grade: S275-E28; Profile: UPF-100*50*4; Name: PANNE; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.000928351 m3; Gross volume: 0.000903329 m3; Gross footprint area: 0 m2; Net surface area: 0.475382 m2; Gross area: 0 m2; Height: 100 mm; Width: 50 mm; Length: 1208.79 mm; sets with these values: 2
BaseQuantities - Length: 1208.79 mm; OuterSurfaceArea: 0.475382 m2; NetVolume: 0.000928351 m3; NetWeight: 0 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm)
PANNE | -2641.38 | 28630.4
PANNE | -1362.97 | 28630.4
PANNE | -2641.38 | 3630.35
PANNE | -1362.97 | 3630.35

# IfcBeam: UPF-200*80*4 (4)
In: Undefined
Description: UPF-200*80*4; Material: /S275-E28
Tekla Common - Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: UPF-200*80*4; Name: MONTANT; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Gross area: 0 m2; Height: 200 mm; Width: 80 mm; sets with these values: 2
BaseQuantities - NetWeight: 0 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
MONTANT | 3519.27 | -2175.37 | 32230 | +3.500 | +3.580 | 103 | M3 | 0.0056151 | 0.00553136 | 0.031904 | 2.84227 | 3988
MONTANT | 1818.5 | -4194.64 | 32230 | -0.285 | +3.922 | 105 | M5 | 0.00592346 | 0.00583511 | 0.001408 | 2.9982 | 4207
MONTANT | 1818.5 | -156.093 | 32230 | -0.285 | +3.922 | 104 | M4 | 0.00592346 | 0.00583511 | 0.001408 | 2.9982 | 4207
MONTANT | 3822 | -2175.37 | 32310.7 | +3.722 | +3.922 | 103 | M3 | 0.0056151 | 0.00553136 | 0.31904 | 2.84227 | 3988

# IfcBeam: UPN100 (32)
In: Undefined
Description: UPN100; Material: /S275-E28
Tekla Common - Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: UPN100; Name: ECLISSE; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Gross footprint area: 0 m2; Height: 100 mm; Width: 50 mm; sets with these values: 2
BaseQuantities - NetWeight: 0 kg
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Phase | Net volume (m3) = NetVolume (m3) | Gross volume (m3) | Net surface area (m2) | Gross area (m2) = OuterSurfaceArea (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm)
ECLISSE | 4335.87 | -3234.09 | 27258.9 | +4.285 | +4.387 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4273.95 | -5003.48 | 27258.9 | +4.223 | +4.325 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4150.09 | 4597.82 | 27258.9 | +4.100 | +4.201 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4335.87 | -710.382 | 27258.9 | +4.285 | +4.387 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4273.95 | 1059.01 | 27258.9 | +4.223 | +4.325 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4212.01 | 2828.4 | 27258.9 | +4.161 | +4.263 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4335.87 | -3234.09 | 21258.9 | +4.285 | +4.387 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4273.95 | -5003.48 | 21258.9 | +4.223 | +4.325 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4212.01 | -6772.88 | 21258.9 | +4.161 | +4.263 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4150.09 | 4597.82 | 21258.9 | +4.100 | +4.201 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4335.87 | -710.382 | 21258.9 | +4.285 | +4.387 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4273.95 | 1059.01 | 21258.9 | +4.223 | +4.325 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4212.01 | 2828.4 | 21258.9 | +4.161 | +4.263 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4335.87 | -3234.09 | 15258.9 | +4.285 | +4.387 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4273.95 | -5003.48 | 15258.9 | +4.223 | +4.325 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4212.01 | -6772.88 | 15258.9 | +4.161 | +4.263 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4150.09 | 4597.82 | 15258.9 | +4.100 | +4.201 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4335.87 | -710.382 | 15258.9 | +4.285 | +4.387 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4273.95 | 1059.01 | 15258.9 | +4.223 | +4.325 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4212.01 | 2828.4 | 15258.9 | +4.161 | +4.263 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4150.86 | -8520.4 | 9435.87 | +4.100 | +4.203 | 137 | EC8 | 1 | 0.000476208 | 0.000485818 | 0.139477 | 0.13387 | 359.865
ECLISSE | 4150.09 | -8542.33 | 9078.32 | +4.100 | +4.201 | 137 | EC8 | 1 | 0.00047621 | 0.00048582 | 0.139478 | 0.13387 | 359.867
ECLISSE | 4335.87 | -3234.09 | 9258.87 | +4.285 | +4.387 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4273.95 | -5003.48 | 9258.87 | +4.223 | +4.325 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4212.01 | -6772.88 | 9258.87 | +4.161 | +4.263 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4150.09 | 4597.82 | 9258.87 | +4.100 | +4.201 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4335.87 | -710.382 | 9258.87 | +4.285 | +4.387 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4273.95 | 1059.01 | 9258.87 | +4.223 | +4.325 | EC9 | EC9 | 6 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4212.01 | 2828.4 | 9258.87 | +4.161 | +4.263 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4227.64 | -6326.47 | 27256.7 | +4.176 | +4.280 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4201.79 | -7065.11 | 21256.7 | +4.150 | +4.254 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720
ECLISSE | 4175.93 | -7803.76 | 15256.7 | +4.124 | +4.229 | EC9 | EC9 | 1 | 0.000955354 | 0.000972 | 0.277147 | 0.26784 | 720

# IfcColumn: D24 (32)
In: Undefined
Description: D24; Material: STEEL/S235JR
Tekla Common - Center of gravity Z: -440.559 mm; Bottom elevation: -0.700; Top elevation: -0.200; Part mark: 74; Assembly mark: PS24B1; Phase: 1; Class: 2; Finish: BRUT; Grade: S235JR; Profile: D24; Name: TIGE D'ANCRAGE; sets with these values: 2
Tekla Quantity - Net weight: 1.50602 kg; Gross weight: 1.50602 kg; Weight: 1.50602 kg; Net volume: 0.00019185 m3; Gross volume: 0.00019185 m3; Gross footprint area: 0.000432 m2; Area per tons: 23.8774 m2; Net surface area: 0.0359599 m2; Gross area: 0.0359599 m2; Height: 24 mm; Width: 24 mm; Length: 500 mm; sets with these values: 2
BaseQuantities - Length: 500 mm; OuterSurfaceArea: 0.0359599 m2; NetVolume: 0.00019185 m3; NetWeight: 1.50602 kg
Name | Center of gravity Y (mm) | Center of gravity X (mm)
TIGE D'ANCRAGE | -100.364 | 32230
TIGE D'ANCRAGE | -250.364 | 32230
TIGE D'ANCRAGE | -4100.31 | 32230
TIGE D'ANCRAGE | -4250.31 | 32230
TIGE D'ANCRAGE | -8629.47 | 763.869
TIGE D'ANCRAGE | 4685 | 4898.87
TIGE D'ANCRAGE | -8629.47 | 613.869
TIGE D'ANCRAGE | 4685 | 613.869
TIGE D'ANCRAGE | 4685 | 763.869
TIGE D'ANCRAGE | 4685 | 5048.87
TIGE D'ANCRAGE | 4685 | 9183.87
TIGE D'ANCRAGE | 4685 | 9333.87
TIGE D'ANCRAGE | 4685 | 15183.9
TIGE D'ANCRAGE | 4685 | 15333.9
TIGE D'ANCRAGE | 4685 | 21183.9
TIGE D'ANCRAGE | 4685 | 21333.9
TIGE D'ANCRAGE | 4685 | 27183.9
TIGE D'ANCRAGE | 4685 | 27333.9
TIGE D'ANCRAGE | 4685 | 32083.9
TIGE D'ANCRAGE | 4685 | 32233.9
TIGE D'ANCRAGE | -8629.47 | 4898.87
TIGE D'ANCRAGE | -8629.47 | 5048.87
TIGE D'ANCRAGE | -8629.47 | 9183.87
TIGE D'ANCRAGE | -8629.47 | 9333.87
TIGE D'ANCRAGE | -7868.04 | 15183.9
TIGE D'ANCRAGE | -7868.04 | 15333.9
TIGE D'ANCRAGE | -7137.49 | 21183.9
TIGE D'ANCRAGE | -7137.49 | 21333.9
TIGE D'ANCRAGE | -6406.93 | 27183.9
TIGE D'ANCRAGE | -6406.93 | 27333.9
TIGE D'ANCRAGE | -5810.31 | 32083.9
TIGE D'ANCRAGE | -5810.31 | 32233.9

# IfcColumn: PL15*135 (7)
In: Undefined
Description: PL15*135; Material: /S275-E28
Tekla Common - Center of gravity Z: 4184.39 mm; Center of gravity Y: -1979.86 mm; Bottom elevation: +4.054; Top elevation: +4.314; Part mark: 70; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL15*135; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.000526875 m3; Gross volume: 0.000526875 m3; Gross footprint area: 0.002025 m2; Net surface area: 0.0821056 m2; Gross area: 0.0821056 m2; Height: 135 mm; Width: 15 mm; Length: 260.185 mm; sets with these values: 2
BaseQuantities - Length: 260.185 mm; OuterSurfaceArea: 0.0821056 m2; NetVolume: 0.000526875 m3; NetWeight: 0 kg
Name | Center of gravity X (mm) | Assembly mark
GOUSSET | 4973.87 | T1
GOUSSET | 688.868 | T10
GOUSSET | 9258.87 | T8
GOUSSET | 15258.9 | T4
GOUSSET | 21258.9 | T5
GOUSSET | 27258.9 | T6
GOUSSET | 32158.9 | T9

# IfcColumn: UPF-100*50*3, MONTANT
In: Undefined
Description: UPF-100*50*3; Material: /S275-E28
Tekla Common - Center of gravity Z: 1025 mm; Center of gravity Y: -4391.74 mm; Center of gravity X: 32280 mm; Bottom elevation: -0.045; Top elevation: +2.095; Part mark: 66; Assembly mark: M1; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: UPF-100*50*3; Name: MONTANT; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.00124548 m3; Gross volume: 0.00122044 m3; Gross footprint area: 0.000582 m2; Net surface area: 0.844324 m2; Gross area: 0 m2; Height: 100 mm; Width: 50 mm; Length: 2140 mm; sets with these values: 2
BaseQuantities - Length: 2140 mm; OuterSurfaceArea: 0.844324 m2; NetVolume: 0.00124548 m3; NetWeight: 0 kg

# IfcElementAssembly (318)
In: Undefined
Tekla Assembly - sets with these values: 2
Name | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit name | Assembly/Cast unit position code | Assembly/Cast unit Mark
2 x LISSE | 0 | +3.804 | +4.700 | LISSE | 2-3/B | L20
GOUSSET | 0 | +4.572 | +4.700 | GOUSSET | 1-2/B | ATP4
GOUSSET | 0 | +4.497 | +4.700 | GOUSSET | 3-4/B | ATP3
LISSE | 0 | +4.700 | +4.800 | LISSE | 1-4/B | L17
LISSE | 0 | +2.970 | +4.800 | LISSE | 3-4/B | L19
LISSE | 0 | +2.970 | +4.858 | LISSE | 1-4/B | L18
GOUSSET | 0 | +4.800 | +5.665 | GOUSSET | 1-2/B> | G10
2 x ECLISSE | 0 | +4.285 | +4.387 | ECLISSE | 6/A-B | EC9
2 x GOUSSET | 0 | +4.272 | +4.383 | GOUSSET | 6/A-B | EC2
2 x ECLISSE | 0 | +4.223 | +4.325 | ECLISSE | 6/A-B | EC9
2 x GOUSSET | 0 | +4.210 | +4.321 | GOUSSET | 6/A-B | EC2
ECLISSE | 0 | +4.100 | +4.201 | ECLISSE | 6/B | EC9
GOUSSET | 0 | +4.086 | +4.197 | GOUSSET | 6/B | EC2
ECLISSE | 0 | +4.161 | +4.263 | ECLISSE | 6/A-B | EC9
GOUSSET | 0 | +4.148 | +4.259 | GOUSSET | 6/A-B | EC2
2 x ECLISSE | 0 | +4.285 | +4.387 | ECLISSE | 5/A-B | EC9
2 x GOUSSET | 0 | +4.272 | +4.383 | GOUSSET | 5/A-B | EC2
2 x ECLISSE | 0 | +4.223 | +4.325 | ECLISSE | 5/A-B | EC9
2 x GOUSSET | 0 | +4.210 | +4.321 | GOUSSET | 5/A-B | EC2
2 x ECLISSE | 0 | +4.161 | +4.263 | ECLISSE | 5/A-B | EC9
2 x GOUSSET | 0 | +4.148 | +4.259 | GOUSSET | 5/A-B | EC2
ECLISSE | 0 | +4.100 | +4.201 | ECLISSE | 5/B | EC9
GOUSSET | 0 | +4.086 | +4.197 | GOUSSET | 5/B | EC2
2 x ECLISSE | 0 | +4.285 | +4.387 | ECLISSE | 4/A-B | EC9
2 x GOUSSET | 0 | +4.272 | +4.383 | GOUSSET | 4/A-B | EC2
2 x ECLISSE | 0 | +4.223 | +4.325 | ECLISSE | 4/A-B | EC9
2 x GOUSSET | 0 | +4.210 | +4.321 | GOUSSET | 4/A-B | EC2
2 x ECLISSE | 0 | +4.161 | +4.263 | ECLISSE | 4/A-B | EC9
2 x GOUSSET | 0 | +4.148 | +4.259 | GOUSSET | 4/A-B | EC2
ECLISSE | 0 | +4.100 | +4.201 | ECLISSE | 4/B | EC9
GOUSSET | 0 | +4.086 | +4.197 | GOUSSET | 4/B | EC2
ECLISSE | 0 | +4.100 | +4.203 | ECLISSE | 3/A | EC8
GOUSSET | 0 | +4.086 | +4.198 | GOUSSET | 3/A | EC1
2 x ECLISSE | 0 | +4.285 | +4.387 | ECLISSE | 3/A-B | EC9
GOUSSET | 0 | +4.272 | +4.383 | GOUSSET | 3/A-B | EC2
2 x ECLISSE | 0 | +4.223 | +4.325 | ECLISSE | 3/A-B | EC9
2 x GOUSSET | 0 | +4.210 | +4.321 | GOUSSET | 3/A-B | EC2
2 x ECLISSE | 0 | +4.161 | +4.263 | ECLISSE | 3/A-B | EC9
2 x GOUSSET | 0 | +4.148 | +4.259 | GOUSSET | 3/A-B | EC2
ECLISSE | 0 | +4.100 | +4.201 | ECLISSE | 3/B | EC9
GOUSSET | 0 | +4.086 | +4.197 | GOUSSET | 3/B | EC2
GOUSSET | 0 | +4.272 | +4.383 | GOUSSET | 3/A-B | EC6
2 x GOUSSET | 0 | +4.272 | +4.383 | GOUSSET | 7/A-B | EC3
2 x GOUSSET | 0 | +4.210 | +4.321 | GOUSSET | 7/A-B | EC3
GOUSSET | 0 | +4.086 | +4.197 | GOUSSET | 7/B | EC4
GOUSSET | 0 | +4.148 | +4.259 | GOUSSET | 7/A-B | EC3
2 x GOUSSET | 0 | +4.317 | +4.427 | GOUSSET | 7/A-B | EC5
2 x GOUSSET | 0 | +4.317 | +4.427 | GOUSSET | 6/A-B | EC5
2 x GOUSSET | 0 | +4.317 | +4.427 | GOUSSET | 2/A-B | EC5
2 x GOUSSET | 0 | +4.317 | +4.427 | GOUSSET | 1/A-B | EC5
GOUSSET | 0 | +4.086 | +4.197 | GOUSSET | 2/A | EC3
GOUSSET | 0 | +4.086 | +4.197 | GOUSSET | 1/A | EC3
2 x GOUSSET | 0 | +4.272 | +4.383 | GOUSSET | 2/A-B | EC3
2 x GOUSSET | 0 | +4.272 | +4.383 | GOUSSET | 1/A-B | EC3
2 x GOUSSET | 0 | +4.210 | +4.321 | GOUSSET | 2/A-B | EC3
2 x GOUSSET | 0 | +4.210 | +4.321 | GOUSSET | 1/A-B | EC3
2 x GOUSSET | 0 | +4.148 | +4.259 | GOUSSET | 2/A-B | EC3
2 x GOUSSET | 0 | +4.148 | +4.259 | GOUSSET | 1/A-B | EC3
GOUSSET | 0 | +4.086 | +4.197 | GOUSSET | 2/B | EC7
GOUSSET | 0 | +4.086 | +4.197 | GOUSSET | 1/B | EC3
PANNE | 0 | +4.274 | +4.396 | PANNE | 5-6/A-B | K17
PANNE | 0 | +4.274 | +4.396 | PANNE | 4-5/A-B | K17
2 x PANNE | 0 | +4.212 | +4.334 | PANNE | 4-5/A-B | K17
2 x PANNE | 0 | +4.212 | +4.334 | PANNE | 3-4/A-B | K17
2 x PANNE | 0 | +4.212 | +4.334 | PANNE | 6-7/A-B | K19
TRAVERSE | 0 | +3.616 | +4.319 | TRAVERSE | 6/A-B | T6
2 x PANNE | 0 | +4.212 | +4.334 | PANNE | 5-6/A-B | K17
PANNE | 0 | +4.150 | +4.272 | PANNE | 5-6/A-B | K21
5 x GOUSSET | 0 | +4.575 | +4.700 | GOUSSET | 7/A-B | ATP1
2 x PRESCELLE | 7.93634 | -0.700 | -0.200 | PRESCELLE | 7/A-B | PS24B1
LISSE | 0 | +4.700 | +4.800 | LISSE | 6-7/A-B | L6
LISSE | 0 | +4.700 | +4.800 | LISSE | 5-6/A-B | L5
LISSE | 0 | +4.700 | +4.800 | LISSE | 4-5/A-B | L5
LISSE | 0 | +4.700 | +4.800 | LISSE | 3-4/A-B | L4
LISSE | 0 | +4.700 | +4.800 | LISSE | 2-3/A | L3
LISSE | 0 | +4.700 | +4.800 | LISSE | 1-2/A | L2
ATTACHE | 0 | +2.050 | +2.100 | ATTACHE | 7/A-B | A1
2 x MONTANT | 0 | -0.050 | +2.100 | MONTANT | 7/A-B | M1
MONTANT | 0 | +3.500 | +3.580 | MONTANT | 7/A-B | M3
MONTANT | 0 | -0.300 | +4.695 | MONTANT | 7/A-B | M4
MONTANT | 0 | -0.300 | +4.695 | MONTANT | 7/A-B | M5
LISSE | 0 | +4.700 | +4.800 | LISSE | 7/A-B | L1
GOUSSET | 0 | +4.086 | +4.102 | GOUSSET | 3/B | G7
2 x CV | 0 | +4.145 | +4.272 | CV | 2-3/A-B | CV1
2 x LIEN | 0 | +4.172 | +4.276 | LIEN | 3-4/A-B | L12
GOUSSET | 0 | +4.268 | +4.285 | GOUSSET | 2/A-B | G9
2 x CV | 0 | +4.235 | +4.275 | CV | 2-3/A-B | CV2
GOUSSET | 0 | +4.086 | +4.102 | GOUSSET | 2/A | G7
2 x STABILITE | 0 | -0.230 | +3.865 | STABILITE | 2-3/A | ST1
BUTON | 0 | +3.766 | +4.055 | BUTON | 2-3/A | B1
2 x GOUSSET | 0 | +4.575 | +4.700 | GOUSSET | 1/A | ATP1
BUTON | 0 | +3.766 | +4.055 | BUTON | 2-3/B | B1
PANNE | 0 | +4.320 | +4.440 | PANNE | 1-2/A-B | K5
PANNE | 0 | +4.320 | +4.440 | PANNE | 6-7/A-B | K4
2 x STABILITE | 0 | -0.230 | +3.865 | STABILITE | 2-3/B | ST1
2 x GOUSSET | 0 | +4.575 | +4.700 | GOUSSET | 2/A | ATP1
PANNE | 0 | +4.150 | +4.272 | PANNE | 4-5/A-B | K14
PANNE | 0 | +4.166 | +4.310 | PANNE | 6-7/A-B | K16
PANNE | 0 | +4.140 | +4.288 | PANNE | 5-6/A-B | K3
2 x PANNE | 0 | +4.150 | +4.272 | PANNE | 3-4/A-B | K21
PANNE | 0 | +4.114 | +4.262 | PANNE | 4-5/A-B | K3
PANNE | 0 | +4.088 | +4.236 | PANNE | 3-4/A-B | K3
PANNE | 0 | +4.274 | +4.396 | PANNE | 1-3/A-B | K11
PANNE | 0 | +4.150 | +4.272 | PANNE | 1-3/A-B | K7
PANNE | 0 | +4.088 | +4.211 | PANNE | 1-3/A | K9
PANNE | 0 | +4.274 | +4.396 | PANNE | 6-7/A-B | K20
PANNE | 0 | +4.150 | +4.272 | PANNE | 4-5/A-B | K21
PANNE | 0 | +4.150 | +4.272 | PANNE | 6-7/A-B | K8
2 x PANNE | 0 | +4.274 | +4.396 | PANNE | 3-4/A-B | K17
PANNE | 0 | +4.274 | +4.396 | PANNE | 1-3/A-B | K10
PANNE | 0 | +4.274 | +4.396 | PANNE | 4-5/A-B | K18
PANNE | 0 | +4.150 | +4.272 | PANNE | 1-3/A-B | K6
PANNE | 0 | +4.088 | +4.211 | PANNE | 6-7/B | K15
PANNE | 0 | +4.088 | +4.211 | PANNE | 5-6/B | K1
PANNE | 0 | +4.088 | +4.211 | PANNE | 4-5/B | K1
PANNE | 0 | +4.088 | +4.211 | PANNE | 3-4/B | K1
TRAVERSE | 0 | +3.637 | +4.319 | TRAVERSE | 7/A-B | T9
TRAVERSE | 0 | +3.538 | +4.319 | TRAVERSE | 7/A-B | T7
TRAVERSE | 0 | +3.538 | +4.319 | TRAVERSE | 6/A-B | T10
TRAVERSE | 0 | +3.538 | +4.319 | TRAVERSE | 3/A-B | T2
2 x TRAVERSE | 0 | +3.538 | +4.319 | TRAVERSE | 2/A-B | T1
TRAVERSE | 0 | +3.538 | +4.319 | TRAVERSE | 5/A-B | T3
TRAVERSE | 0 | +3.565 | +4.319 | TRAVERSE | 4/A-B | T4
TRAVERSE | 0 | +3.538 | +4.319 | TRAVERSE | 3/A-B | T8
POTEAU | 0 | -0.300 | +4.695 | POTEAU | 2/A | P5
POTEAU | 0 | -0.300 | +4.695 | POTEAU | 3/A | P6
TRAVERSE | 0 | +3.590 | +4.319 | TRAVERSE | 5/A-B | T5
PRESCELLE | 7.93635 | -0.700 | -0.200 | PRESCELLE | 3/A | PS24B1
POTEAU | 0 | -0.300 | +4.695 | POTEAU | 6/A-B | P12
GOUSSET | 0 | -0.000 | +3.000 | GOUSSET | 6/A-B | MTP4
PRESCELLE | 7.93635 | -0.700 | -0.200 | PRESCELLE | 2/A | PS24B1
TRAVERSE | 0 | +3.538 | +4.319 | TRAVERSE | 4/A-B | T3
PRESCELLE | 7.93635 | -0.700 | -0.200 | PRESCELLE | 1/A | PS24B1
POTEAU | 0 | -0.300 | +4.093 | POTEAU | 6/B | P7
PRESCELLE | 7.93635 | -0.700 | -0.200 | PRESCELLE | 4/B | PS24B1
POTEAU | 0 | -0.300 | +4.695 | POTEAU | 1/A | P9
2 x POTEAU | 0 | -0.000 | +4.000 | POTEAU | 6-7/B | P2
POTEAU | 0 | -0.000 | +4.000 | POTEAU | 5-6/B | P2
POTEAU | 0 | -0.000 | +4.800 | POTEAU | 7/B | P1
POTEAU | 0 | -0.000 | +4.800 | POTEAU | 6/B | P1
POTEAU | 0 | -0.000 | +4.800 | POTEAU | 5-6/B | P1
POTEAU | 0 | -0.000 | +4.000 | POTEAU | 5/B | P2
POTEAU | 0 | -0.000 | +4.800 | POTEAU | 4-5/B | P1
2 x POTEAU | 0 | -0.000 | +4.800 | POTEAU | 3-4/B | P1
MUR | 0 | -0.000 | +5.800 | MUR | ./A-B | MUR1
MUR | 0 | -0.000 | +4.800 | MUR | .-1/A-B | MUR2
POTEAU | 0 | -0.300 | +4.093 | POTEAU | 1/B | P7
POTEAU | 0 | -0.300 | +4.093 | POTEAU | 2/B | P3
MUR | 0 | -0.000 | +4.800 | MUR | .-4/B> | MUR3
MUR | 0 | -0.000 | +4.800 | MUR | 3-7/B> | MUR4
GOUSSET | 0 | -0.000 | +4.300 | GOUSSET | 6-7/A-B | G1
GOUSSET | 0 | -0.000 | +4.300 | GOUSSET | 4-5/A-B | G2
MUR | 0 | +3.326 | +4.300 | MUR | 4-7/A-B | MUR5
POTEAU | 0 | -0.300 | +4.093 | POTEAU | 5/B | P7
PRESCELLE | 7.93635 | -0.700 | -0.200 | PRESCELLE | 2/B | PS24B1
POTEAU | 0 | -0.300 | +4.093 | POTEAU | 3/B | P4
PRESCELLE | 7.93635 | -0.700 | -0.200 | PRESCELLE | 3/B | PS24B1
PRESCELLE | 7.93635 | -0.700 | -0.200 | PRESCELLE | 1/B | PS24B1
POTEAU | 0 | -0.300 | +4.695 | POTEAU | 7/B | P8
PRESCELLE | 7.93635 | -0.700 | -0.200 | PRESCELLE | 5/B | PS24B1
POTEAU | 0 | -0.300 | +4.695 | POTEAU | 5/A-B | P11
PRESCELLE | 7.93635 | -0.700 | -0.200 | PRESCELLE | 6/B | PS24B1
POTEAU | 0 | -0.300 | +4.093 | POTEAU | 4/B | P7
PRESCELLE | 7.93635 | -0.700 | -0.200 | PRESCELLE | 7/B | PS24B1
PRESCELLE | 7.93635 | -0.700 | -0.200 | PRESCELLE | 4/A-B | PS24B1
GOUSSET | 0 | +3.000 | +4.100 | GOUSSET | 6/A-B | MTP2
POTEAU | 0 | -0.300 | +4.695 | POTEAU | 7/A-B | P13
PRESCELLE | 7.93635 | -0.700 | -0.200 | PRESCELLE | 5/A-B | PS24B1
GOUSSET | 0 | -0.000 | +3.000 | GOUSSET | 5/A-B | MTP4
PANNE | 0 | +4.088 | +4.211 | PANNE | 1-3/B | K2
PRESCELLE | 7.93635 | -0.700 | -0.200 | PRESCELLE | 6/A-B | PS24B1
GOUSSET | 0 | +0.000 | +3.000 | GOUSSET | 7/A-B | MTP4
POTEAU | 0 | -0.300 | +4.695 | POTEAU | 4/A-B | P10
PRESCELLE | 7.93635 | -0.700 | -0.200 | PRESCELLE | 7/A-B | PS24B1
2 x TRAVERSE | 0 | +3.538 | +4.319 | TRAVERSE | 1/A-B | T10
PANNE | 0 | +4.212 | +4.334 | PANNE | 1-3/A-B | K12
PANNE | 0 | +4.212 | +4.334 | PANNE | 1-3/A-B | K13
PANNE | 0 | +4.274 | +4.396 | PANNE | 5-6/A-B | K18
PANNE | 0 | +4.274 | +4.396 | PANNE | 6-7/A-B | K22
2 x GOUSSET | 0 | +4.575 | +4.700 | GOUSSET | 3/A | ATP1
2 x GOUSSET | 0 | +4.575 | +4.700 | GOUSSET | 4/A-B | ATP1
2 x GOUSSET | 0 | +4.575 | +4.700 | GOUSSET | 5/A-B | ATP1
2 x GOUSSET | 0 | +4.575 | +4.700 | GOUSSET | 6/A-B | ATP1
GOUSSET | 0 | +4.575 | +4.700 | GOUSSET | 7/A-B | ATP2
2 x GOUSSET | 0 | +4.575 | +4.700 | GOUSSET | 7/B | ATP1
MONTANT | 0 | +3.722 | +3.922 | MONTANT | 7/A-B | M3
GOUSSET | 0 | +3.000 | +4.100 | GOUSSET | 5/A-B | MTP2
MONTANT | 0 | +2.100 | +2.150 | MONTANT | 7/A-B | M2
GOUSSET | 0 | +3.000 | +4.150 | GOUSSET | 7/A-B | MTP3
GOUSSET | 0 | -0.000 | +3.000 | GOUSSET | 4/A-B | MTP4
GOUSSET | 0 | +3.000 | +4.090 | GOUSSET | 4/A-B | MTP1
GOUSSET | 0 | +4.185 | +4.296 | GOUSSET | 7/A-B | EC3
GOUSSET | 0 | +4.162 | +4.276 | GOUSSET | 6/A-B | EC2
ECLISSE | 0 | +4.176 | +4.280 | ECLISSE | 6/A-B | EC9
GOUSSET | 0 | +4.137 | +4.250 | GOUSSET | 5/A-B | EC2
ECLISSE | 0 | +4.150 | +4.254 | ECLISSE | 5/A-B | EC9
GOUSSET | 0 | +4.111 | +4.224 | GOUSSET | 4/A-B | EC2
ECLISSE | 0 | +4.124 | +4.229 | ECLISSE | 4/A-B | EC9
GOUSSET | 0 | +4.086 | +4.102 | GOUSSET | 3/A | G8
2 x CV | 0 | +4.054 | +4.181 | CV | 2-3/A-B | CV1
2 x GOUSSET | 0 | +4.268 | +4.285 | GOUSSET | 3/A-B | G5
2 x CV | 0 | +4.144 | +4.272 | CV | 2-3/A-B | CV1
LIEN | 0 | +4.136 | +4.214 | LIEN | 6-7/A-B | L13
GOUSSET | 0 | +4.086 | +4.102 | GOUSSET | 2/B | G6
2 x CV | 0 | +4.053 | +4.181 | CV | 2-3/A-B | CV1
2 x GOUSSET | 0 | +4.177 | +4.192 | GOUSSET | 2-3/A-B | G4
GOUSSET | 0 | +4.268 | +4.285 | GOUSSET | 2/A-B | G5
2 x CV | 0 | +4.285 | +4.325 | CV | 2-3/A-B | CV2
2 x LIEN | 0 | +4.110 | +4.214 | LIEN | 3-4/A-B | L12
LIEN | 0 | +4.048 | +4.153 | LIEN | 3-4/A-B | L10
2 x LIEN | 0 | +4.172 | +4.276 | LIEN | 4-5/A-B | L12
2 x LIEN | 0 | +4.110 | +4.214 | LIEN | 4-5/A-B | L12
LIEN | 0 | +4.048 | +4.153 | LIEN | 4-5/A-B | L10
2 x LIEN | 0 | +4.172 | +4.276 | LIEN | 5-6/A-B | L12
LIEN | 0 | +4.110 | +4.214 | LIEN | 5-6/A-B | L12
LIEN | 0 | +4.048 | +4.153 | LIEN | 5-6/A-B | L10
2 x LIEN | 0 | +4.172 | +4.276 | LIEN | 6-7/A-B | L12
LIEN | 0 | +4.110 | +4.214 | LIEN | 6-7/A-B | L12
LIEN | 0 | +4.048 | +4.153 | LIEN | 6-7/A-B | L12
2 x LIEN | 0 | +4.172 | +4.276 | LIEN | 1-2/A-B | L12
2 x LIEN | 0 | +4.110 | +4.214 | LIEN | 1-2/A-B | L12
2 x LIEN | 0 | +4.048 | +4.153 | LIEN | 1-2/A-B | L12
2 x LIEN | 0 | +4.172 | +4.276 | LIEN | 2-3/A-B | L12
2 x LIEN | 0 | +4.110 | +4.214 | LIEN | 2-3/A-B | L7
2 x LIEN | 0 | +4.048 | +4.153 | LIEN | 2-3/A-B | L12
LIEN | 0 | +4.235 | +4.275 | LIEN | 4-5/A-B | L15
LIEN | 0 | +4.235 | +4.275 | LIEN | 3-4/A-B | L15
LIEN | 0 | +4.235 | +4.275 | LIEN | 2-3/A-B | L11
LIEN | 0 | +4.235 | +4.275 | LIEN | 1-2/A-B | L15
LIEN | 0 | +4.113 | +4.214 | LIEN | 5-6/A-B | L14
LIEN | 0 | +4.087 | +4.153 | LIEN | 4-5/A-B | L9
LIEN | 0 | +4.061 | +4.153 | LIEN | 3-4/A-B | L8
LIEN | 0 | +4.235 | +4.275 | LIEN | 5-6/A-B | L16
LIEN | 0 | +4.235 | +4.275 | LIEN | 6-7/A-B | L16
GOUSSET | 0 | +4.275 | +4.280 | GOUSSET | 2-3/A-B | G3
2 x PANNE | 0 | +4.296 | +4.446 | PANNE | 6-7/A-B | K23
2 x PANNE | 0 | +4.296 | +4.446 | PANNE | 1-2/A-B | K23

# IfcMechanicalFastener: Bolt assembly (499)
In: Undefined
Tekla Fastener - Slotted hole x: 0 mm; Location: Montage; sets with these values: 2
Name | NominalDiameter (mm) = Washer diameter (mm) = Bolt size (mm) | NominalLength (mm) = Bolt length (mm) | Washer count | Washer type | Washer name | Nut count | Nut type | Nut name | Slotted hole y (mm) | Bolt hole diameter (mm) | Bolt count | Bolt standard | Bolt Name
2 x Bolt assembly | 12 | 69.2 | 0 | PLA-6.8 | RONDELLE-M12-PLA-6.8 | 2 | E-6.8 | ECROU-M12-E-6.8 | 0 | 14 | 2 | HILTI-HSA | HILTI_HSA_M12X80
71 x Bolt assembly | 12 | 30 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 3 | E-8.8 | ECROU-M12-E-8.8 | 0 | 14 | 3 | 8.8 | M12*30
145 x Bolt assembly | 12 | 30 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-8.8 | ECROU-M12-E-8.8 | 0 | 14 | 2 | 8.8 | M12*30
2 x Bolt assembly | 12 | 40 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 1 | E-8.8 | ECROU-M12-E-8.8 | 0 | 14 | 1 | 8.8 | M12*40
5 x Bolt assembly | 12 | 40 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-8.8 | ECROU-M12-E-8.8 | 0 | 14 | 2 | 8.8 | M12*40
64 x Bolt assembly | 18 | 15 | 0 | PLA-6.8 | RONDELLE-M18-PLA-6.8 | 0 | E-6.8 | ECROU-M18-E-6.8 | 0 | 26 | 1 | 6.8 | M18*30
16 x Bolt assembly | 20 | 15 | 0 | PLA-6.8 | RONDELLE-M20-PLA-6.8 | 0 | E-6.8 | ECROU-M20-E-6.8 | 0 | 50 | 2 | 6.8 | M20*40
16 x Bolt assembly | 18 | 10 | 0 | PLA-6.8 | RONDELLE-M18-PLA-6.8 | 0 | E-6.8 | ECROU-M18-E-6.8 | 0 | 26 | 2 | 6.8 | M18*30
14 x Bolt assembly | 16 | 60 | 24 | PLA-HR10.9 | RONDELLE-M16-PLA-HR10.9 | 12 | E-HR10.9 | ECROU-M16-E-HR10.9 | 0 | 18 | 12 | HR10.9 | M16*60
20 x Bolt assembly | 12 | 3 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 0 | E-8.8 | ECROU-M12-E-8.8 | 0 | 30 | 1 | 8.8 | M12*25
7 x Bolt assembly | 12 | 30 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 5 | E-8.8 | ECROU-M12-E-8.8 | 0 | 14 | 5 | 8.8 | M12*30
7 x Bolt assembly | 16 | 70 | 12 | PLA-HR10.9 | RONDELLE-M16-PLA-HR10.9 | 6 | E-HR10.9 | ECROU-M16-E-HR10.9 | 0 | 18 | 6 | HR10.9 | M16*70
4 x Bolt assembly | 16 | 40 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 4 | E-8.8 | ECROU-M16-E-8.8 | 0 | 18 | 4 | 8.8 | M16*40
22 x Bolt assembly | 12 | 30 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 1 | E-8.8 | ECROU-M12-E-8.8 | 0 | 14 | 1 | 8.8 | M12*30
2 x Bolt assembly | 12 | 40 | 4 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-8.8 | ECROU-M12-E-8.8 | 25 | 14 | 2 | 8.8 | M12*40
2 x Bolt assembly | 12 | 160 | 0 | PLA-6.8 | RONDELLE-M12-PLA-6.8 | 2 | E-6.8 | ECROU-M12-E-6.8 | 0 | 14 | 2 | HILTI-HAS | HILTI_HAS_M12_28_6.8
Bolt assembly | 12 | 40 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 3 | E-8.8 | ECROU-M12-E-8.8 | 0 | 14 | 3 | 8.8 | M12*40
Bolt assembly | 12 | 40 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 5 | E-8.8 | ECROU-M12-E-8.8 | 0 | 14 | 5 | 8.8 | M12*40
88 x Bolt assembly | 10 | 30 | 0 | PLA-8.8 | RONDELLE-M10-PLA-8.8 | 2 | E-8.8 | ECROU-M10-E-8.8 | 0 | 12 | 2 | 8.8 | M10*30
2 x Bolt assembly | 10 | 100 | 0 | PLA-8.8 | RONDELLE-M10-PLA-8.8 | 2 | E-8.8 | ECROU-M10-E-8.8 | 0 | 12 | 2 | 8.8 | M10*100
8 x Bolt assembly | 4 | 5 | 0 | PLA-6.8 | RONDELLE-M4-PLA-6.8 | 0 | E-6.8 | ECROU-M4-E-6.8 | 0 | 6 | 2 | 6.8 | M4*10

# IfcPlate: PL5*100 (2)
In: Undefined
Description: PL5*100; Material: /S275-E28
Tekla Common - Center of gravity Z: -47.5 mm; Center of gravity X: 32280 mm; Bottom elevation: -0.050; Top elevation: -0.045; Part mark: 123; Assembly mark: M1; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL5*100; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.00007 m3; Gross volume: 0.00007 m3; Gross footprint area: 0.014 m2; Net surface area: 0.0304 m2; Gross area: 0.014 m2; Height: 100 mm; Width: 5 mm; Length: 140 mm; sets with these values: 2
Name | Center of gravity Y (mm)
GOUSSET | -5545.37
GOUSSET | -4335.36

# IfcPlate: PL5*50 (4)
In: Undefined
Description: PL5*50; Material: /S275-E28
Tekla Common - Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL5*50; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Height: 50 mm; Width: 5 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark | Net volume (m3) = Gross volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Gross area (m2) | Length (mm)
GOUSSET | 2097.5 | -5500.37 | 32280 | +2.095 | +2.100 | 121 | M1 | 0.000025 | 0.005 | 0.0115 | 0.005 | 100
GOUSSET | 2097.5 | -4380.36 | 32280 | +2.095 | +2.100 | 121 | M1 | 0.000025 | 0.005 | 0.0115 | 0.005 | 100
GOUSSET | 2125 | -4257.87 | 32230 | +2.100 | +2.150 | 122 | M5 | 0.00005 | 0.001 | 0.0225 | 0.01 | 200
GOUSSET | 2125 | -4262.87 | 32280 | +2.100 | +2.150 | 121 | M2 | 0.000025 | 0.0005 | 0.0115 | 0.005 | 100

# IfcPlate: PL6*119 (4)
In: Undefined
Description: PL6*119; Material: /S275-E28
Tekla Common - Center of gravity Z: 3835.28 mm; Bottom elevation: +3.766; Top elevation: +3.885; Part mark: 78; Assembly mark: B1; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL6*119; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.0000908754 m3; Gross volume: 0.0000908754 m3; Gross footprint area: 0.000861224 m2; Net surface area: 0.0332285 m2; Gross area: 0.0188451 m2; Height: 118.868 mm; Width: 6 mm; Length: 158.538 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm)
GOUSSET | 4750 | 5071.37
GOUSSET | 4750 | 9161.35
GOUSSET | -8694.59 | 5071.37
GOUSSET | -8694.59 | 9161.35

# IfcPlate: PL6*167 (4)
In: Undefined
Description: PL6*167; Material: /S275-E28
Tekla Common - Bottom elevation: -0.285; Top elevation: -0.131; Part mark: 79; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL6*167; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.000141296 m3; Gross volume: 0.000141296 m3; Gross footprint area: 0.000832022 m2; Net surface area: 0.0506567 m2; Gross area: 0.0256632 m2; Height: 166.787 mm; Width: 6 mm; Length: 153.868 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Assembly mark
GOUSSET | -206.479 | 4750 | 9177.7 | P4
GOUSSET | -206.478 | 4750 | 5055.03 | P3
GOUSSET | -206.479 | -8694.59 | 9177.7 | P6
GOUSSET | -206.478 | -8694.59 | 5055.03 | P5

# IfcPlate: PL6*80 (4)
In: Undefined
Description: PL6*80; Material: /S275-E28
Tekla Common - Part mark: 76; Assembly mark: M3; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL6*80; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.0000960261 m3; Gross volume: 0.0000960261 m3; Net surface area: 0.0353694 m2; Gross area: 0.0160087 m2; Height: 80 mm; Width: 6 mm; Length: 200.109 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Gross footprint area (m2)
GOUSSET | 3540 | -4172.37 | 32230 | +3.500 | +3.580 | 0.00120061
GOUSSET | 3540 | -178.354 | 32230 | +3.500 | +3.580 | 0.00120061
GOUSSET | 3821.98 | -4172.37 | 32290 | +3.722 | +3.922 | 0.00048
GOUSSET | 3821.98 | -178.354 | 32290 | +3.722 | +3.922 | 0.00048

# IfcPlate: PL6*86 (2)
In: Undefined
Description: PL6*86; Material: /S275-E28
Tekla Common - Center of gravity Z: 4121.5 mm; Center of gravity X: 32166.9 mm; Bottom elevation: +4.079; Top elevation: +4.165; Part mark: 77; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL6*86; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.0000516 m3; Gross volume: 0.0000516 m3; Gross footprint area: 0.0006 m2; Net surface area: 0.019432 m2; Gross area: 0.0086 m2; Height: 86 mm; Width: 6 mm; Length: 100 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Assembly mark
GOUSSET | -160.368 | M4
GOUSSET | -4190.36 | M5

# IfcPlate: PL8*120 (4)
In: Undefined
Description: PL8*120; Material: /S275-E28
Tekla Common - Center of gravity Z: 3934.72 mm; Bottom elevation: +3.815; Top elevation: +4.055; Part mark: 19; Assembly mark: B1; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL8*120; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.0002304 m3; Gross volume: 0.0002304 m3; Gross footprint area: 0.00096 m2; Net surface area: 0.06336 m2; Gross area: 0.0288 m2; Height: 120 mm; Width: 8 mm; Length: 240 mm; sets with these values: 2
Name | Center of gravity Y (mm) | Center of gravity X (mm)
GOUSSET | 4750 | 9250.87
GOUSSET | 4750 | 4981.87
GOUSSET | -8694.59 | 4981.87
GOUSSET | -8694.59 | 9250.87

# IfcPlate: PL8*160 (4)
In: Undefined
Description: PL8*160; Material: /S275-E28
Tekla Common - Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL8*160; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.000463476 m3; Gross volume: 0.000463476 m3; Gross footprint area: 0 m2; Net surface area: 0.124232 m2; Gross area: 0.059492 m2; Height: 160 mm; Width: 8 mm; Length: 371.825 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Part mark | Assembly mark
GOUSSET | 4134.47 | -7158.69 | 21258.2 | +4.124 | +4.145 | 16 | P11
GOUSSET | 4108.9 | -7889.19 | 15258.2 | +4.098 | +4.119 | 15 | P10
GOUSSET | 4160.04 | -6428.13 | 27258.2 | +4.149 | +4.170 | 17 | P12
GOUSSET | 4180.93 | -5831.45 | 32158.2 | +4.170 | +4.191 | 18 | P13

# IfcPlate: PL8*70 (28)
In: Undefined
Description: PL8*70; Material: /S275-E28
Tekla Common - Part mark: 20; Phase: 1; Class: 1; Finish: ANTI-BLEU; Grade: S275-E28; Profile: PL8*70; Name: GOUSSET; sets with these values: 2
Tekla Quantity - Net weight: 0 kg; Gross weight: 0 kg; Weight: 0 kg; Net volume: 0.00016816 m3; Gross volume: 0.00016816 m3; Gross footprint area: 0.02102 m2; Net surface area: 0.0478685 m2; Gross area: 0.02142 m2; Height: 70 mm; Width: 8 mm; Length: 306 mm; sets with these values: 2
Name | Center of gravity Z (mm) | Center of gravity Y (mm) | Center of gravity X (mm) | Bottom elevation | Top elevation | Assembly mark
GOUSSET | 3562.77 | 4684.94 | 649.578 | +3.559 | +3.567 | P7
GOUSSET | 3562.77 | 4684.94 | 728.157 | +3.559 | +3.567 | P7
GOUSSET | 3562.77 | 4684.94 | 4934.58 | +3.559 | +3.567 | P3
GOUSSET | 3562.77 | 4684.94 | 5013.16 | +3.559 | +3.567 | P3
GOUSSET | 3562.77 | 4684.94 | 9298.16 | +3.559 | +3.567 | P4
GOUSSET | 3562.77 | 4684.94 | 9219.58 | +3.559 | +3.567 | P4
GOUSSET | 3562.77 | 4684.94 | 15298.2 | +3.559 | +3.567 | P7
GOUSSET | 3562.77 | 4684.94 | 15219.6 | +3.559 | +3.567 | P7
GOUSSET | 3562.77 | 4684.94 | 27298.2 | +3.559 | +3.567 | P7
GOUSSET | 3562.77 | 4684.94 | 27219.6 | +3.559 | +3.567 | P7
GOUSSET | 3562.77 | 4684.94 | 21298.2 | +3.559 | +3.567 | P7
GOUSSET | 3562.77 | 4684.94 | 21219.6 | +3.559 | +3.567 | P7
GOUSSET | 3562.77 | -8629.52 | 5013.16 | +3.559 | +3.567 | P5
GOUSSET | 3562.77 | -8629.52 | 4934.58 | +3.559 | +3.567 | P5
GOUSSET | 3562.77 | -8629.52 | 728.157 | +3.559 | +3.567 | P9
GOUSSET | 3562.77 | -8629.52 | 649.578 | +3.559 | +3.567 | P9
GOUSSET | 3562.77 | -8629.52 | 9298.16 | +3.559 | +3.567 | P6
GOUSSET | 3562.77 | -8629.52 | 9219.58 | +3.559 | +3.567 | P6
GOUSSET | 3585.42 | -7868.16 | 15298.2 | +3.581 | +3.589 | P10
GOUSSET | 3585.42 | -7868.16 | 15219.6 | +3.581 | +3.589 | P10
GOUSSET | 3610.99 | -7137.6 | 21298.2 | +3.607 | +3.615 | P11
GOUSSET | 3610.99 | -7137.6 | 21219.6 | +3.607 | +3.615 | P11
GOUSSET | 3640.56 | -6407.04 | 27298.2 | +3.637 | +3.645 | P12
GOUSSET | 3640.56 | -6407.04 | 27219.6 | +3.637 | +3.645 | P12
GOUSSET | 3661.44 | -5810.42 | 32198.2 | +3.657 | +3.665 | P13
GOUSSET | 3661.44 | -5810.42 | 32119.6 | +3.657 | +3.665 | P13
GOUSSET | 3562.77 | 4684.94 | 32198.2 | +3.559 | +3.567 | P8
GOUSSET | 3562.77 | 4684.94 | 32119.6 | +3.559 | +3.567 | P8
